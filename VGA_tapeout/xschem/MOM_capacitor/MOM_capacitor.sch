v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 30 -0 90 -0 { lab=in}
N 570 0 630 0 { lab=out}
N 310 140 310 200 { lab=out}
C {devices/iopin.sym} 40 0 2 0 {name=p1 lab=in}
C {devices/iopin.sym} 620 0 0 0 {name=p2 lab=out}
C {devices/iopin.sym} 310 190 1 0 {name=p3 lab=gnd}

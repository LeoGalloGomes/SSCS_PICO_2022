v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 8900 50 8900 140 { lab=gnd}
N 8600 50 8600 140 { lab=gnd}
N 8300 50 8300 140 { lab=gnd}
N 8000 50 8000 140 { lab=gnd}
N 7700 50 7700 140 { lab=gnd}
N 7400 50 7400 140 { lab=gnd}
N 7100 50 7100 140 { lab=gnd}
N 6800 50 6800 140 { lab=gnd}
N 6500 50 6500 140 { lab=gnd}
N 6200 50 6200 140 { lab=gnd}
N 5900 50 5900 140 { lab=gnd}
N 5600 50 5600 140 { lab=gnd}
N 5300 50 5300 140 { lab=gnd}
N 5000 50 5000 140 { lab=gnd}
N 4700 50 4700 140 { lab=gnd}
N 4400 50 4400 140 { lab=gnd}
N 4100 50 4100 140 { lab=gnd}
N 3800 50 3800 140 { lab=gnd}
N 3500 50 3500 140 { lab=gnd}
N 3200 50 3200 140 { lab=gnd}
N 2900 50 2900 140 { lab=gnd}
N 2600 50 2600 140 { lab=gnd}
N 2300 50 2300 140 { lab=gnd}
N 2000 50 2000 140 { lab=gnd}
N 1700 50 1700 140 { lab=gnd}
N 1400 50 1400 140 { lab=gnd}
N 1100 50 1100 140 { lab=gnd}
N 800 50 800 140 { lab=gnd}
N 500 50 500 140 { lab=gnd}
N 200 50 200 140 { lab=gnd}
N -0 0 50 -0 { lab=in}
N 9050 0 9120 0 { lab=out}
N 200 140 8900 140 { lab=gnd}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 200 0 0 0 {name=x1}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 500 0 0 0 {name=x2}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 800 0 0 0 {name=x3}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 1100 0 0 0 {name=x4}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 1400 0 0 0 {name=x5}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 1700 0 0 0 {name=x6}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 2000 0 0 0 {name=x7}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 2300 0 0 0 {name=x8}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 2600 0 0 0 {name=x9}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 2900 0 0 0 {name=x10}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 3200 0 0 0 {name=x11}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 3500 0 0 0 {name=x12}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 3800 0 0 0 {name=x13}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 4100 0 0 0 {name=x14}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 4400 0 0 0 {name=x15}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 4700 0 0 0 {name=x16}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 5000 0 0 0 {name=x17}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 5300 0 0 0 {name=x18}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 5600 0 0 0 {name=x19}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 5900 0 0 0 {name=x20}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 6200 0 0 0 {name=x21}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 6500 0 0 0 {name=x22}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 6800 0 0 0 {name=x23}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 7100 0 0 0 {name=x24}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 7400 0 0 0 {name=x25}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 7700 0 0 0 {name=x26}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 8000 0 0 0 {name=x27}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 8300 0 0 0 {name=x28}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 8600 0 0 0 {name=x29}
C {/home/leonardo/sky130_projects/SSCS_PICO/VGA_Vband/SCPW_segment_3p55um.sym} 8900 0 0 0 {name=x30}
C {devices/iopin.sym} 10 0 2 0 {name=p1 lab=in}
C {devices/iopin.sym} 210 140 2 0 {name=p3 lab=gnd}
C {devices/iopin.sym} 9110 0 0 0 {name=p2 lab=out}

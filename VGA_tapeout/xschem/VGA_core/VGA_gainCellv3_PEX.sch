** sch_path: VGA_tapeout/xschem/VGA_core/VGA_gainCellv3_PEX.sch
**.subckt VGA_gainCellv3_PEX in out gate Vdd Vctrl gnd
*.iopin in
*.iopin out
*.iopin gate
*.iopin Vdd
*.iopin Vctrl
*.iopin gnd
**** begin user architecture code

X0 out.t29 gatea.t0 a_47_7835# gnd.t79 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs0 gate.t0 gatea.t0 477.35
X1 gnd.t116 ina.t0 a_47_7835# gnd.t115 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs1 in.t0 ina.t0 518.45
X2 out.t28 gatea.t1 a_47_7835# gnd.t78 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs2 gate.t1 gatea.t1 477.35
X3 Vdd.t29 Vctrl.t0 a_47_7835# gnd.t47 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
X4 a_47_7835# ina.t1 gnd.t41 gnd.t40 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs4 in.t1 ina.t1 518.45
X5 a_47_7835# Vctrl.t1 Vdd.t28 gnd.t106 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X6 a_47_7835# gatea.t2 out.t27 gnd.t77 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs6 gate.t2 gatea.t2 477.35
X7 a_47_7835# Vctrl.t2 Vdd.t27 gnd.t125 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X8 gnd.t28 ina.t2 a_47_7835# gnd.t27 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs8 in.t2 ina.t2 518.45
X9 out.t26 gatea.t3 a_47_7835# gnd.t76 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs9 gate.t3 gatea.t3 477.35
X10 a_47_7835# ina.t3 gnd.t30 gnd.t29 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs10 in.t3 ina.t3 518.45
X11 a_47_7835# Vctrl.t3 Vdd.t26 gnd.t107 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X12 a_47_7835# gnd.t20 gnd.t22 gnd.t21 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
X13 a_47_7835# Vctrl.t4 Vdd.t25 gnd.t108 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X14 gnd.t19 gnd.t16 gnd.t18 gnd.t17 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
X15 out.t25 gatea.t4 a_47_7835# gnd.t75 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs15 gate.t4 gatea.t4 477.35
X16 gnd.t37 ina.t4 a_47_7835# gnd.t36 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs16 in.t4 ina.t4 518.45
X17 gnd.t122 ina.t5 a_47_7835# gnd.t121 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs17 in.t5 ina.t5 518.45
X18 a_47_7835# gatea.t5 out.t24 gnd.t74 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs18 gate.t5 gatea.t5 477.35
X19 a_47_7835# Vctrl.t5 Vdd.t24 gnd.t136 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X20 Vdd.t23 Vctrl.t6 a_47_7835# gnd.t90 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X21 a_47_7835# gatea.t6 out.t23 gnd.t73 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs21 gate.t6 gatea.t6 477.35
X22 a_47_7835# Vctrl.t7 Vdd.t22 gnd.t99 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X23 out.t22 gatea.t7 a_47_7835# gnd.t72 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs23 gate.t7 gatea.t7 477.35
X24 out.t21 gatea.t8 a_47_7835# gnd.t71 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs24 gate.t8 gatea.t8 477.35
X25 out.t20 gatea.t9 a_47_7835# gnd.t70 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs25 gate.t9 gatea.t9 477.35
X26 gnd.t118 ina.t6 a_47_7835# gnd.t117 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs26 in.t6 ina.t6 518.45
X27 gnd.t92 ina.t7 a_47_7835# gnd.t91 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs27 in.t7 ina.t7 518.45
X28 Vdd.t21 Vctrl.t8 a_47_7835# gnd.t89 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X29 a_47_7835# ina.t8 gnd.t127 gnd.t126 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs29 in.t8 ina.t8 518.45
X30 Vdd.t20 Vctrl.t9 a_47_7835# gnd.t105 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X31 a_47_7835# gatea.t10 out.t19 gnd.t69 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs31 gate.t10 gatea.t10 477.35
X32 gnd.t85 ina.t9 a_47_7835# gnd.t84 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs32 in.t9 ina.t9 518.45
X33 a_47_7835# Vctrl.t10 Vdd.t19 gnd.t23 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X34 a_47_7835# gatea.t11 out.t18 gnd.t68 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs34 gate.t11 gatea.t11 477.35
X35 a_47_7835# ina.t10 gnd.t33 gnd.t32 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs35 in.t10 ina.t10 518.45
X36 Vdd.t18 Vctrl.t11 a_47_7835# gnd.t141 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X37 out.t17 gatea.t12 a_47_7835# gnd.t67 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs37 gate.t12 gatea.t12 477.35
X38 gnd.t129 ina.t11 a_47_7835# gnd.t128 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs38 in.t11 ina.t11 518.45
X39 gnd.t15 gnd.t13 a_47_7835# gnd.t14 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
X40 a_47_7835# ina.t12 gnd.t131 gnd.t130 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs40 in.t12 ina.t12 518.45
X41 out.t16 gatea.t13 a_47_7835# gnd.t66 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs41 gate.t13 gatea.t13 477.35
X42 gnd gnd.t8 gnd gnd.t9 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X43 Vdd.t17 Vctrl.t12 a_47_7835# gnd.t135 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X44 a_47_7835# Vctrl.t13 Vdd.t16 gnd.t24 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X45 a_47_7835# gatea.t14 out.t15 gnd.t65 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs45 gate.t14 gatea.t14 477.35
X46 a_47_7835# ina.t13 gnd.t112 gnd.t111 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs46 in.t13 ina.t13 518.45
X47 Vdd.t15 Vctrl.t14 a_47_7835# gnd.t134 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X48 gnd.t101 ina.t14 a_47_7835# gnd.t100 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs48 in.t14 ina.t14 518.45
X49 a_47_7835# ina.t15 gnd.t94 gnd.t93 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs49 in.t15 ina.t15 518.45
X50 a_47_7835# gatea.t15 out.t14 gnd.t64 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs50 gate.t15 gatea.t15 477.35
X51 a_47_7835# Vctrl.t15 Vdd.t14 gnd.t88 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X52 Vdd.t13 Vctrl.t16 a_47_7835# gnd.t138 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X53 a_47_7835# Vctrl.t17 Vdd.t12 gnd.t44 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X54 out.t13 gatea.t16 a_47_7835# gnd.t63 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs54 gate.t16 gatea.t16 477.35
X55 a_47_7835# ina.t16 gnd.t120 gnd.t119 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs55 in.t16 ina.t16 518.45
X56 Vdd.t11 Vctrl.t18 a_47_7835# gnd.t31 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X57 out.t12 gatea.t17 a_47_7835# gnd.t62 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs57 gate.t17 gatea.t17 477.35
X58 gnd.t49 ina.t17 a_47_7835# gnd.t48 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs58 in.t17 ina.t17 518.45
X59 a_47_7835# gnd.t5 gnd.t7 gnd.t6 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
X60 gnd.t4 gnd.t2 a_47_7835# gnd.t3 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
X61 Vctrl.t19 gnd.t103 sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.5e+07u
X62 a_47_7835# ina.t18 gnd.t87 gnd.t86 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs62 in.t18 ina.t18 518.45
X63 a_47_7835# gatea.t18 out.t11 gnd.t61 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs63 gate.t18 gatea.t18 477.35
X64 a_47_7835# Vctrl.t20 Vdd.t10 gnd.t132 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X65 Vdd.t9 Vctrl.t21 a_47_7835# gnd.t123 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X66 a_47_7835# gatea.t19 out.t10 gnd.t60 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs66 gate.t19 gatea.t19 477.35
X67 gnd.t81 ina.t19 a_47_7835# gnd.t80 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs67 in.t19 ina.t19 518.45
X68 a_47_7835# Vctrl.t22 Vdd.t8 gnd.t102 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X69 a_47_7835# ina.t20 gnd.t110 gnd.t109 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs69 in.t20 ina.t20 518.45
X70 Vdd.t7 Vctrl.t23 a_47_7835# gnd.t0 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
X71 out.t9 gatea.t20 a_47_7835# gnd.t59 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs71 gate.t20 gatea.t20 477.35
X72 gnd.t46 ina.t21 a_47_7835# gnd.t45 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs72 in.t21 ina.t21 518.45
X73 a_47_7835# ina.t22 gnd.t43 gnd.t42 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs73 in.t22 ina.t22 518.45
X74 a_47_7835# Vctrl.t24 Vdd.t6 gnd.t139 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X75 out.t8 gatea.t21 a_47_7835# gnd.t58 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs75 gate.t21 gatea.t21 477.35
X76 gnd.t39 ina.t23 a_47_7835# gnd.t38 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs76 in.t23 ina.t23 518.45
X77 a_47_7835# Vctrl.t25 Vdd.t5 gnd.t140 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X78 a_47_7835# gatea.t22 out.t7 gnd.t57 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs78 gate.t22 gatea.t22 477.35
X79 a_47_7835# ina.t24 gnd.t26 gnd.t25 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs79 in.t24 ina.t24 518.45
X80 Vdd.t4 Vctrl.t26 a_47_7835# gnd.t1 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
X81 a_47_7835# gatea.t23 out.t6 gnd.t56 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs81 gate.t23 gatea.t23 477.35
X82 gnd.t83 ina.t25 a_47_7835# gnd.t82 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs82 in.t25 ina.t25 518.45
X83 a_47_7835# gatea.t24 out.t5 gnd.t55 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs83 gate.t24 gatea.t24 477.35
X84 a_47_7835# ina.t26 gnd.t35 gnd.t34 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs84 in.t26 ina.t26 518.45
X85 Vdd.t3 Vctrl.t27 a_47_7835# gnd.t142 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X86 out.t4 gatea.t25 a_47_7835# gnd.t54 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs86 gate.t25 gatea.t25 477.35
X87 a_47_7835# Vctrl.t28 Vdd.t2 gnd.t104 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X88 out.t3 gatea.t26 a_47_7835# gnd.t53 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs88 gate.t26 gatea.t26 477.35
X89 Vdd.t1 Vctrl.t29 a_47_7835# gnd.t133 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X90 gnd.t114 ina.t27 a_47_7835# gnd.t113 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs90 in.t27 ina.t27 518.45
X91 a_47_7835# gatea.t27 out.t2 gnd.t52 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs91 gate.t27 gatea.t27 477.35
X92 a_47_7835# gatea.t28 out.t1 gnd.t51 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs92 gate.t28 gatea.t28 477.35
X93 a_47_7835# ina.t28 gnd.t98 gnd.t97 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs93 in.t28 ina.t28 518.45
X94 Vdd.t30 gnd.t124 sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.5e+07u
X95 Vdd.t0 Vctrl.t30 a_47_7835# gnd.t137 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
X96 a_47_7835# ina.t29 gnd.t96 gnd.t95 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u
+ l=150000u
Rnqs96 in.t29 ina.t29 518.45
X97 a_47_7835# gatea.t29 out.t0 gnd.t50 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u
+ w=840000u l=150000u
Rnqs97 gate.t29 gatea.t29 477.35
C0 a_47_7835# out 12.82960fF
C1 Vdd out 0.20935fF
C2 gate out 3.13023fF
C3 in a_47_7835# 3.06764fF
C4 Vctrl a_47_7835# 4.30536fF
C5 Vdd a_47_7835# 12.82960fF
C6 Vctrl Vdd 3.22382fF
C7 a_47_7835# gate 4.24674fF
R0 gate.n0 gate.t25 231.02
R1 gate.n14 gate.t18 231.02
R2 gate.n1 gate.t0 230.836
R3 gate.n3 gate.t12 230.836
R4 gate.n5 gate.t4 230.836
R5 gate.n7 gate.t16 230.836
R6 gate.n9 gate.t1 230.836
R7 gate.n11 gate.t3 230.836
R8 gate.n13 gate.t8 230.836
R9 gate.n0 gate.t9 230.836
R10 gate.n2 gate.t20 230.836
R11 gate.n4 gate.t21 230.836
R12 gate.n6 gate.t26 230.836
R13 gate.n8 gate.t7 230.836
R14 gate.n10 gate.t13 230.836
R15 gate.n12 gate.t17 230.836
R16 gate.n27 gate.t24 230.836
R17 gate.n26 gate.t11 230.836
R18 gate.n25 gate.t28 230.836
R19 gate.n24 gate.t5 230.836
R20 gate.n23 gate.t15 230.836
R21 gate.n22 gate.t23 230.836
R22 gate.n21 gate.t10 230.836
R23 gate.n20 gate.t19 230.836
R24 gate.n19 gate.t29 230.836
R25 gate.n18 gate.t6 230.836
R26 gate.n17 gate.t27 230.836
R27 gate.n16 gate.t14 230.836
R28 gate.n15 gate.t22 230.836
R29 gate.n14 gate.t2 230.836
R30 gate.n28 gate.n27 0.521
R31 gate.n28 gate.n13 0.429
R32 gate gate.n28 0.21
R33 gate.n1 gate.n0 0.184
R34 gate.n2 gate.n1 0.184
R35 gate.n3 gate.n2 0.184
R36 gate.n4 gate.n3 0.184
R37 gate.n5 gate.n4 0.184
R38 gate.n6 gate.n5 0.184
R39 gate.n7 gate.n6 0.184
R40 gate.n8 gate.n7 0.184
R41 gate.n9 gate.n8 0.184
R42 gate.n10 gate.n9 0.184
R43 gate.n11 gate.n10 0.184
R44 gate.n12 gate.n11 0.184
R45 gate.n13 gate.n12 0.184
R46 gate.n15 gate.n14 0.184
R47 gate.n16 gate.n15 0.184
R48 gate.n17 gate.n16 0.184
R49 gate.n18 gate.n17 0.184
R50 gate.n19 gate.n18 0.184
R51 gate.n20 gate.n19 0.184
R52 gate.n21 gate.n20 0.184
R53 gate.n22 gate.n21 0.184
R54 gate.n23 gate.n22 0.184
R55 gate.n24 gate.n23 0.184
R56 gate.n25 gate.n24 0.184
R57 gate.n26 gate.n25 0.184
R58 gate.n27 gate.n26 0.184
R59 out.n138 out.t10 23.571
R60 out.n138 out.t3 23.571
R61 out.n54 out.t5 23.571
R62 out.n54 out.t21 23.571
R63 out.n45 out.t18 23.571
R64 out.n45 out.t12 23.571
R65 out.n36 out.t1 23.571
R66 out.n36 out.t26 23.571
R67 out.n27 out.t24 23.571
R68 out.n27 out.t16 23.571
R69 out.n18 out.t14 23.571
R70 out.n18 out.t28 23.571
R71 out.n9 out.t6 23.571
R72 out.n9 out.t22 23.571
R73 out.n0 out.t19 23.571
R74 out.n0 out.t13 23.571
R75 out.n69 out.t0 23.571
R76 out.n69 out.t25 23.571
R77 out.n78 out.t23 23.571
R78 out.n78 out.t8 23.571
R79 out.n87 out.t2 23.571
R80 out.n87 out.t17 23.571
R81 out.n96 out.t15 23.571
R82 out.n96 out.t9 23.571
R83 out.n105 out.t7 23.571
R84 out.n105 out.t29 23.571
R85 out.n114 out.t27 23.571
R86 out.n114 out.t20 23.571
R87 out.n123 out.t11 23.571
R88 out.n123 out.t4 23.571
R89 out.n144 out.n139 8.032
R90 out.n51 out.n46 8.032
R91 out.n42 out.n37 8.032
R92 out.n33 out.n28 8.032
R93 out.n24 out.n19 8.032
R94 out.n15 out.n10 8.032
R95 out.n6 out.n1 8.032
R96 out.n75 out.n70 8.032
R97 out.n84 out.n79 8.032
R98 out.n93 out.n88 8.032
R99 out.n102 out.n97 8.032
R100 out.n111 out.n106 8.032
R101 out.n120 out.n115 8.032
R102 out.n129 out.n124 8.032
R103 out.n60 out.n55 8.031
R104 out.n141 out.n140 3.85
R105 out.n57 out.n56 3.85
R106 out.n48 out.n47 3.85
R107 out.n39 out.n38 3.85
R108 out.n30 out.n29 3.85
R109 out.n21 out.n20 3.85
R110 out.n12 out.n11 3.85
R111 out.n3 out.n2 3.85
R112 out.n72 out.n71 3.85
R113 out.n81 out.n80 3.85
R114 out.n90 out.n89 3.85
R115 out.n99 out.n98 3.85
R116 out.n108 out.n107 3.85
R117 out.n117 out.n116 3.85
R118 out.n126 out.n125 3.85
R119 out.n139 out.n138 1.601
R120 out.n55 out.n54 1.601
R121 out.n46 out.n45 1.601
R122 out.n37 out.n36 1.601
R123 out.n28 out.n27 1.601
R124 out.n19 out.n18 1.601
R125 out.n10 out.n9 1.601
R126 out.n1 out.n0 1.601
R127 out.n70 out.n69 1.601
R128 out.n79 out.n78 1.601
R129 out.n88 out.n87 1.601
R130 out.n97 out.n96 1.601
R131 out.n106 out.n105 1.601
R132 out.n115 out.n114 1.601
R133 out.n124 out.n123 1.601
R134 out.n63 out.n62 0.63
R135 out.n132 out.n131 0.63
R136 out.n61 out.n60 0.619
R137 out.n145 out.n144 0.618
R138 out.n52 out.n51 0.618
R139 out.n43 out.n42 0.618
R140 out.n34 out.n33 0.618
R141 out.n25 out.n24 0.618
R142 out.n16 out.n15 0.618
R143 out.n7 out.n6 0.618
R144 out.n76 out.n75 0.618
R145 out.n85 out.n84 0.618
R146 out.n94 out.n93 0.618
R147 out.n103 out.n102 0.618
R148 out.n112 out.n111 0.618
R149 out.n121 out.n120 0.618
R150 out.n130 out.n129 0.618
R151 out.n147 out.n146 0.568
R152 out.n63 out.n53 0.568
R153 out.n64 out.n44 0.568
R154 out.n65 out.n35 0.568
R155 out.n66 out.n26 0.568
R156 out.n67 out.n17 0.568
R157 out.n68 out.n8 0.568
R158 out.n137 out.n77 0.568
R159 out.n136 out.n86 0.568
R160 out.n135 out.n95 0.568
R161 out.n134 out.n104 0.568
R162 out.n133 out.n113 0.568
R163 out.n132 out.n122 0.568
R164 out.n60 out.n59 0.098
R165 out.n144 out.n143 0.098
R166 out.n51 out.n50 0.098
R167 out.n42 out.n41 0.098
R168 out.n33 out.n32 0.098
R169 out.n24 out.n23 0.098
R170 out.n15 out.n14 0.098
R171 out.n6 out.n5 0.098
R172 out.n75 out.n74 0.098
R173 out.n84 out.n83 0.098
R174 out.n93 out.n92 0.098
R175 out.n102 out.n101 0.098
R176 out.n111 out.n110 0.098
R177 out.n120 out.n119 0.098
R178 out.n129 out.n128 0.098
R179 out.n133 out.n132 0.062
R180 out.n134 out.n133 0.062
R181 out.n135 out.n134 0.062
R182 out.n136 out.n135 0.062
R183 out.n137 out.n136 0.062
R184 out.n147 out.n137 0.062
R185 out.n147 out.n68 0.062
R186 out.n68 out.n67 0.062
R187 out.n67 out.n66 0.062
R188 out.n66 out.n65 0.062
R189 out.n65 out.n64 0.062
R190 out.n64 out.n63 0.062
R191 out.n146 out.n145 0.037
R192 out.n62 out.n61 0.037
R193 out.n53 out.n52 0.037
R194 out.n44 out.n43 0.037
R195 out.n35 out.n34 0.037
R196 out.n26 out.n25 0.037
R197 out.n17 out.n16 0.037
R198 out.n8 out.n7 0.037
R199 out.n77 out.n76 0.037
R200 out.n86 out.n85 0.037
R201 out.n95 out.n94 0.037
R202 out.n104 out.n103 0.037
R203 out.n113 out.n112 0.037
R204 out.n122 out.n121 0.037
R205 out.n131 out.n130 0.037
R206 out out.n147 0.024
R207 out.n142 out.n141 0.008
R208 out.n58 out.n57 0.008
R209 out.n49 out.n48 0.008
R210 out.n40 out.n39 0.008
R211 out.n31 out.n30 0.008
R212 out.n22 out.n21 0.008
R213 out.n13 out.n12 0.008
R214 out.n4 out.n3 0.008
R215 out.n73 out.n72 0.008
R216 out.n82 out.n81 0.008
R217 out.n91 out.n90 0.008
R218 out.n100 out.n99 0.008
R219 out.n109 out.n108 0.008
R220 out.n118 out.n117 0.008
R221 out.n127 out.n126 0.008
R222 out.n143 out.n142 0.001
R223 out.n59 out.n58 0.001
R224 out.n50 out.n49 0.001
R225 out.n41 out.n40 0.001
R226 out.n32 out.n31 0.001
R227 out.n23 out.n22 0.001
R228 out.n14 out.n13 0.001
R229 out.n5 out.n4 0.001
R230 out.n74 out.n73 0.001
R231 out.n83 out.n82 0.001
R232 out.n92 out.n91 0.001
R233 out.n101 out.n100 0.001
R234 out.n110 out.n109 0.001
R235 out.n119 out.n118 0.001
R236 out.n128 out.n127 0.001
R237 gnd.n394 gnd.n393 292.5
R238 gnd.n392 gnd.n391 292.5
R239 gnd.n390 gnd.n389 292.5
R240 gnd.n388 gnd.n387 292.5
R241 gnd.n386 gnd.n385 292.5
R242 gnd.n384 gnd.n383 292.5
R243 gnd.n382 gnd.n381 292.5
R244 gnd.n380 gnd.n379 292.5
R245 gnd.n378 gnd.n377 292.5
R246 gnd.n376 gnd.n375 292.5
R247 gnd.n374 gnd.n373 292.5
R248 gnd.n372 gnd.n371 292.5
R249 gnd.n370 gnd.n369 292.5
R250 gnd.n368 gnd.n367 292.5
R251 gnd.n366 gnd.n365 292.5
R252 gnd.n364 gnd.n363 292.5
R253 gnd.n362 gnd.n361 292.5
R254 gnd.n360 gnd.n359 292.5
R255 gnd.n358 gnd.n357 292.5
R256 gnd.n113 gnd.n112 292.5
R257 gnd.n117 gnd.n116 292.5
R258 gnd.n121 gnd.n120 292.5
R259 gnd.n157 gnd.n156 292.5
R260 gnd.n153 gnd.n152 292.5
R261 gnd.n149 gnd.n148 292.5
R262 gnd.n6 gnd.n5 292.5
R263 gnd.n8 gnd.n7 292.5
R264 gnd.n10 gnd.n9 292.5
R265 gnd.n12 gnd.n11 292.5
R266 gnd.n14 gnd.n13 292.5
R267 gnd.n16 gnd.n15 292.5
R268 gnd.n18 gnd.n17 292.5
R269 gnd.n20 gnd.n19 292.5
R270 gnd.n22 gnd.n21 292.5
R271 gnd.n24 gnd.n23 292.5
R272 gnd.n26 gnd.n25 292.5
R273 gnd.n28 gnd.n27 292.5
R274 gnd.n30 gnd.n29 292.5
R275 gnd.n32 gnd.n31 292.5
R276 gnd.n34 gnd.n33 292.5
R277 gnd.n36 gnd.n35 292.5
R278 gnd.n38 gnd.n37 292.5
R279 gnd.n40 gnd.n39 292.5
R280 gnd.n42 gnd.n41 292.5
R281 gnd.n43 gnd.n1 292.5
R282 gnd.n396 gnd.n395 292.5
R283 gnd.n48 gnd.n47 292.5
R284 gnd.n81 gnd.n80 292.5
R285 gnd.n80 gnd.n79 292.5
R286 gnd.n78 gnd.n77 292.5
R287 gnd.n77 gnd.n76 292.5
R288 gnd.n75 gnd.n74 292.5
R289 gnd.n74 gnd.n73 292.5
R290 gnd.n72 gnd.n71 292.5
R291 gnd.n71 gnd.n70 292.5
R292 gnd.n69 gnd.n68 292.5
R293 gnd.n68 gnd.n67 292.5
R294 gnd.n66 gnd.n65 292.5
R295 gnd.n65 gnd.n64 292.5
R296 gnd.n63 gnd.n62 292.5
R297 gnd.n62 gnd.n61 292.5
R298 gnd.n60 gnd.n59 292.5
R299 gnd.n59 gnd.n58 292.5
R300 gnd.n57 gnd.n56 292.5
R301 gnd.n56 gnd.n55 292.5
R302 gnd.n54 gnd.n53 292.5
R303 gnd.n53 gnd.n52 292.5
R304 gnd.n51 gnd.n50 292.5
R305 gnd.n50 gnd.n49 292.5
R306 gnd.n126 gnd.n125 292.5
R307 gnd.n125 gnd.n124 292.5
R308 gnd.n129 gnd.n128 292.5
R309 gnd.n128 gnd.n127 292.5
R310 gnd.n132 gnd.n131 292.5
R311 gnd.n131 gnd.n130 292.5
R312 gnd.n135 gnd.n134 292.5
R313 gnd.n134 gnd.n133 292.5
R314 gnd.n138 gnd.n137 292.5
R315 gnd.n137 gnd.n136 292.5
R316 gnd.n141 gnd.n140 292.5
R317 gnd.n140 gnd.n139 292.5
R318 gnd.n144 gnd.n143 292.5
R319 gnd.n143 gnd.n142 292.5
R320 gnd.n147 gnd.n146 292.5
R321 gnd.n146 gnd.n145 292.5
R322 gnd.n151 gnd.n150 292.5
R323 gnd.n150 gnd.n149 292.5
R324 gnd.n155 gnd.n154 292.5
R325 gnd.n154 gnd.n153 292.5
R326 gnd.n159 gnd.n158 292.5
R327 gnd.n158 gnd.n157 292.5
R328 gnd.n123 gnd.n122 292.5
R329 gnd.n122 gnd.n121 292.5
R330 gnd.n119 gnd.n118 292.5
R331 gnd.n118 gnd.n117 292.5
R332 gnd.n115 gnd.n114 292.5
R333 gnd.n114 gnd.n113 292.5
R334 gnd.n111 gnd.n110 292.5
R335 gnd.n110 gnd.n109 292.5
R336 gnd.n108 gnd.n107 292.5
R337 gnd.n107 gnd.n106 292.5
R338 gnd.n105 gnd.n104 292.5
R339 gnd.n104 gnd.n103 292.5
R340 gnd.n102 gnd.n101 292.5
R341 gnd.n101 gnd.n100 292.5
R342 gnd.n99 gnd.n98 292.5
R343 gnd.n98 gnd.n97 292.5
R344 gnd.n96 gnd.n95 292.5
R345 gnd.n95 gnd.n94 292.5
R346 gnd.n93 gnd.n92 292.5
R347 gnd.n92 gnd.n91 292.5
R348 gnd.n90 gnd.n89 292.5
R349 gnd.n89 gnd.n88 292.5
R350 gnd.n323 gnd.n322 292.5
R351 gnd.n322 gnd.n321 292.5
R352 gnd.n326 gnd.n325 292.5
R353 gnd.n325 gnd.n324 292.5
R354 gnd.n329 gnd.n328 292.5
R355 gnd.n328 gnd.n327 292.5
R356 gnd.n332 gnd.n331 292.5
R357 gnd.n331 gnd.n330 292.5
R358 gnd.n335 gnd.n334 292.5
R359 gnd.n334 gnd.n333 292.5
R360 gnd.n338 gnd.n337 292.5
R361 gnd.n337 gnd.n336 292.5
R362 gnd.n341 gnd.n340 292.5
R363 gnd.n340 gnd.n339 292.5
R364 gnd.n344 gnd.n343 292.5
R365 gnd.n343 gnd.n342 292.5
R366 gnd.n347 gnd.n346 292.5
R367 gnd.n346 gnd.n345 292.5
R368 gnd.n350 gnd.n349 292.5
R369 gnd.n349 gnd.n348 292.5
R370 gnd.n352 gnd.n351 292.5
R371 gnd.n353 gnd.n352 292.5
R372 gnd.n401 gnd.n400 292.5
R373 gnd.n531 gnd.n530 292.5
R374 gnd.n418 gnd.n417 292.5
R375 gnd.n421 gnd.n420 292.5
R376 gnd.n420 gnd.n419 292.5
R377 gnd.n423 gnd.n422 292.5
R378 gnd.n425 gnd.n424 292.5
R379 gnd.n427 gnd.n426 292.5
R380 gnd.n429 gnd.n428 292.5
R381 gnd.n431 gnd.n430 292.5
R382 gnd.n433 gnd.n432 292.5
R383 gnd.n435 gnd.n434 292.5
R384 gnd.n438 gnd.n437 292.5
R385 gnd.n437 gnd.n436 292.5
R386 gnd.n440 gnd.n439 292.5
R387 gnd.n442 gnd.n441 292.5
R388 gnd.n445 gnd.n444 292.5
R389 gnd.n444 gnd.n443 292.5
R390 gnd.n447 gnd.n446 292.5
R391 gnd.n449 gnd.n448 292.5
R392 gnd.n452 gnd.n451 292.5
R393 gnd.n451 gnd.n450 292.5
R394 gnd.n455 gnd.n454 292.5
R395 gnd.n454 gnd.n453 292.5
R396 gnd.n458 gnd.n457 292.5
R397 gnd.n457 gnd.n456 292.5
R398 gnd.n461 gnd.n460 292.5
R399 gnd.n460 gnd.n459 292.5
R400 gnd.n464 gnd.n463 292.5
R401 gnd.n463 gnd.n462 292.5
R402 gnd.n467 gnd.n466 292.5
R403 gnd.n466 gnd.n465 292.5
R404 gnd.n470 gnd.n469 292.5
R405 gnd.n469 gnd.n468 292.5
R406 gnd.n473 gnd.n472 292.5
R407 gnd.n472 gnd.n471 292.5
R408 gnd.n475 gnd.n474 292.5
R409 gnd.n477 gnd.n476 292.5
R410 gnd.n480 gnd.n479 292.5
R411 gnd.n479 gnd.n478 292.5
R412 gnd.n483 gnd.n482 292.5
R413 gnd.n482 gnd.n481 292.5
R414 gnd.n485 gnd.n484 292.5
R415 gnd.n488 gnd.n487 292.5
R416 gnd.n487 gnd.n486 292.5
R417 gnd.n490 gnd.n489 292.5
R418 gnd.n493 gnd.n492 292.5
R419 gnd.n492 gnd.n491 292.5
R420 gnd.n496 gnd.n495 292.5
R421 gnd.n495 gnd.n494 292.5
R422 gnd.n499 gnd.n498 292.5
R423 gnd.n498 gnd.n497 292.5
R424 gnd.n502 gnd.n501 292.5
R425 gnd.n501 gnd.n500 292.5
R426 gnd.n505 gnd.n504 292.5
R427 gnd.n504 gnd.n503 292.5
R428 gnd.n508 gnd.n507 292.5
R429 gnd.n507 gnd.n506 292.5
R430 gnd.n510 gnd.n509 292.5
R431 gnd.n512 gnd.n511 292.5
R432 gnd.n514 gnd.n513 292.5
R433 gnd.n517 gnd.n516 292.5
R434 gnd.n516 gnd.n515 292.5
R435 gnd.n519 gnd.n518 292.5
R436 gnd.n522 gnd.n521 292.5
R437 gnd.n521 gnd.n520 292.5
R438 gnd.n524 gnd.n523 292.5
R439 gnd.n526 gnd.n525 292.5
R440 gnd.n528 gnd.n527 292.5
R441 gnd.n641 gnd.n640 292.5
R442 gnd.n640 gnd.n639 292.5
R443 gnd.n638 gnd.n637 292.5
R444 gnd.n637 gnd.n636 292.5
R445 gnd.n635 gnd.n634 292.5
R446 gnd.n634 gnd.n633 292.5
R447 gnd.n632 gnd.n631 292.5
R448 gnd.n630 gnd.n629 292.5
R449 gnd.n629 gnd.n628 292.5
R450 gnd.n627 gnd.n626 292.5
R451 gnd.n625 gnd.n624 292.5
R452 gnd.n624 gnd.n623 292.5
R453 gnd.n622 gnd.n621 292.5
R454 gnd.n621 gnd.n620 292.5
R455 gnd.n619 gnd.n618 292.5
R456 gnd.n618 gnd.n617 292.5
R457 gnd.n616 gnd.n615 292.5
R458 gnd.n614 gnd.n613 292.5
R459 gnd.n612 gnd.n611 292.5
R460 gnd.n610 gnd.n609 292.5
R461 gnd.n608 gnd.n607 292.5
R462 gnd.n606 gnd.n605 292.5
R463 gnd.n604 gnd.n603 292.5
R464 gnd.n603 gnd.n602 292.5
R465 gnd.n601 gnd.n600 292.5
R466 gnd.n599 gnd.n598 292.5
R467 gnd.n598 gnd.n597 292.5
R468 gnd.n596 gnd.n595 292.5
R469 gnd.n594 gnd.n593 292.5
R470 gnd.n592 gnd.n591 292.5
R471 gnd.n591 gnd.n590 292.5
R472 gnd.n589 gnd.n588 292.5
R473 gnd.n588 gnd.n587 292.5
R474 gnd.n586 gnd.n585 292.5
R475 gnd.n584 gnd.n583 292.5
R476 gnd.n582 gnd.n581 292.5
R477 gnd.n580 gnd.n579 292.5
R478 gnd.n578 gnd.n577 292.5
R479 gnd.n576 gnd.n575 292.5
R480 gnd.n574 gnd.n573 292.5
R481 gnd.n572 gnd.n571 292.5
R482 gnd.n570 gnd.n569 292.5
R483 gnd.n569 gnd.n568 292.5
R484 gnd.n567 gnd.n566 292.5
R485 gnd.n566 gnd.n565 292.5
R486 gnd.n564 gnd.n563 292.5
R487 gnd.n562 gnd.n561 292.5
R488 gnd.n561 gnd.n560 292.5
R489 gnd.n559 gnd.n558 292.5
R490 gnd.n558 gnd.n557 292.5
R491 gnd.n556 gnd.n555 292.5
R492 gnd.n554 gnd.n553 292.5
R493 gnd.n553 gnd.n552 292.5
R494 gnd.n551 gnd.n550 292.5
R495 gnd.n550 gnd.n549 292.5
R496 gnd.n548 gnd.n547 292.5
R497 gnd.n547 gnd.n546 292.5
R498 gnd.n545 gnd.n544 292.5
R499 gnd.n544 gnd.n543 292.5
R500 gnd.n542 gnd.n541 292.5
R501 gnd.n541 gnd.n540 292.5
R502 gnd.n539 gnd.n538 292.5
R503 gnd.n538 gnd.n537 292.5
R504 gnd.n536 gnd.n535 292.5
R505 gnd.n535 gnd.n534 292.5
R506 gnd.n533 gnd.n532 292.5
R507 gnd.n771 gnd.n770 292.5
R508 gnd.n650 gnd.n649 292.5
R509 gnd.n766 gnd.n765 292.5
R510 gnd.n765 gnd.n764 292.5
R511 gnd.n763 gnd.n762 292.5
R512 gnd.n762 gnd.n761 292.5
R513 gnd.n760 gnd.n759 292.5
R514 gnd.n759 gnd.n758 292.5
R515 gnd.n757 gnd.n756 292.5
R516 gnd.n755 gnd.n754 292.5
R517 gnd.n754 gnd.n753 292.5
R518 gnd.n752 gnd.n751 292.5
R519 gnd.n750 gnd.n749 292.5
R520 gnd.n749 gnd.n748 292.5
R521 gnd.n747 gnd.n746 292.5
R522 gnd.n746 gnd.n745 292.5
R523 gnd.n744 gnd.n743 292.5
R524 gnd.n743 gnd.n742 292.5
R525 gnd.n741 gnd.n740 292.5
R526 gnd.n739 gnd.n738 292.5
R527 gnd.n738 gnd.n737 292.5
R528 gnd.n736 gnd.n735 292.5
R529 gnd.n735 gnd.n734 292.5
R530 gnd.n733 gnd.n732 292.5
R531 gnd.n731 gnd.n730 292.5
R532 gnd.n730 gnd.n729 292.5
R533 gnd.n728 gnd.n727 292.5
R534 gnd.n727 gnd.n726 292.5
R535 gnd.n725 gnd.n724 292.5
R536 gnd.n723 gnd.n722 292.5
R537 gnd.n722 gnd.n721 292.5
R538 gnd.n720 gnd.n719 292.5
R539 gnd.n718 gnd.n717 292.5
R540 gnd.n716 gnd.n715 292.5
R541 gnd.n715 gnd.n714 292.5
R542 gnd.n713 gnd.n712 292.5
R543 gnd.n711 gnd.n710 292.5
R544 gnd.n709 gnd.n708 292.5
R545 gnd.n708 gnd.n707 292.5
R546 gnd.n706 gnd.n705 292.5
R547 gnd.n705 gnd.n704 292.5
R548 gnd.n703 gnd.n702 292.5
R549 gnd.n702 gnd.n701 292.5
R550 gnd.n700 gnd.n699 292.5
R551 gnd.n699 gnd.n698 292.5
R552 gnd.n697 gnd.n696 292.5
R553 gnd.n695 gnd.n694 292.5
R554 gnd.n694 gnd.n693 292.5
R555 gnd.n692 gnd.n691 292.5
R556 gnd.n690 gnd.n689 292.5
R557 gnd.n689 gnd.n688 292.5
R558 gnd.n687 gnd.n686 292.5
R559 gnd.n686 gnd.n685 292.5
R560 gnd.n684 gnd.n683 292.5
R561 gnd.n683 gnd.n682 292.5
R562 gnd.n681 gnd.n680 292.5
R563 gnd.n680 gnd.n679 292.5
R564 gnd.n678 gnd.n677 292.5
R565 gnd.n676 gnd.n675 292.5
R566 gnd.n675 gnd.n674 292.5
R567 gnd.n673 gnd.n672 292.5
R568 gnd.n671 gnd.n670 292.5
R569 gnd.n670 gnd.n669 292.5
R570 gnd.n668 gnd.n667 292.5
R571 gnd.n666 gnd.n665 292.5
R572 gnd.n665 gnd.n664 292.5
R573 gnd.n663 gnd.n662 292.5
R574 gnd.n661 gnd.n660 292.5
R575 gnd.n659 gnd.n658 292.5
R576 gnd.n658 gnd.n657 292.5
R577 gnd.n656 gnd.n655 292.5
R578 gnd.n655 gnd.n654 292.5
R579 gnd.n653 gnd.n652 292.5
R580 gnd.n652 gnd.n651 292.5
R581 gnd.n773 gnd.n772 292.5
R582 gnd.n775 gnd.n774 292.5
R583 gnd.n777 gnd.n776 292.5
R584 gnd.n780 gnd.n779 292.5
R585 gnd.n779 gnd.n778 292.5
R586 gnd.n783 gnd.n782 292.5
R587 gnd.n782 gnd.n781 292.5
R588 gnd.n785 gnd.n784 292.5
R589 gnd.n788 gnd.n787 292.5
R590 gnd.n787 gnd.n786 292.5
R591 gnd.n790 gnd.n789 292.5
R592 gnd.n793 gnd.n792 292.5
R593 gnd.n792 gnd.n791 292.5
R594 gnd.n795 gnd.n794 292.5
R595 gnd.n798 gnd.n797 292.5
R596 gnd.n797 gnd.n796 292.5
R597 gnd.n800 gnd.n799 292.5
R598 gnd.n802 gnd.n801 292.5
R599 gnd.n804 gnd.n803 292.5
R600 gnd.n806 gnd.n805 292.5
R601 gnd.n809 gnd.n808 292.5
R602 gnd.n808 gnd.n807 292.5
R603 gnd.n811 gnd.n810 292.5
R604 gnd.n814 gnd.n813 292.5
R605 gnd.n813 gnd.n812 292.5
R606 gnd.n816 gnd.n815 292.5
R607 gnd.n818 gnd.n817 292.5
R608 gnd.n820 gnd.n819 292.5
R609 gnd.n822 gnd.n821 292.5
R610 gnd.n825 gnd.n824 292.5
R611 gnd.n824 gnd.n823 292.5
R612 gnd.n828 gnd.n827 292.5
R613 gnd.n827 gnd.n826 292.5
R614 gnd.n830 gnd.n829 292.5
R615 gnd.n833 gnd.n832 292.5
R616 gnd.n832 gnd.n831 292.5
R617 gnd.n836 gnd.n835 292.5
R618 gnd.n835 gnd.n834 292.5
R619 gnd.n838 gnd.n837 292.5
R620 gnd.n841 gnd.n840 292.5
R621 gnd.n840 gnd.n839 292.5
R622 gnd.n843 gnd.n842 292.5
R623 gnd.n845 gnd.n844 292.5
R624 gnd.n848 gnd.n847 292.5
R625 gnd.n847 gnd.n846 292.5
R626 gnd.n850 gnd.n849 292.5
R627 gnd.n852 gnd.n851 292.5
R628 gnd.n855 gnd.n854 292.5
R629 gnd.n854 gnd.n853 292.5
R630 gnd.n857 gnd.n856 292.5
R631 gnd.n859 gnd.n858 292.5
R632 gnd.n861 gnd.n860 292.5
R633 gnd.n864 gnd.n863 292.5
R634 gnd.n863 gnd.n862 292.5
R635 gnd.n866 gnd.n865 292.5
R636 gnd.n869 gnd.n868 292.5
R637 gnd.n868 gnd.n867 292.5
R638 gnd.n871 gnd.n870 292.5
R639 gnd.n873 gnd.n872 292.5
R640 gnd.n875 gnd.n874 292.5
R641 gnd.n879 gnd.n878 292.5
R642 gnd.n645 gnd.n644 292.5
R643 gnd.n642 gnd.t89 271.703
R644 gnd.n876 gnd.t81 271.703
R645 gnd.n398 gnd.t92 266.304
R646 gnd.n44 gnd.t84 266.304
R647 gnd.n416 gnd.t96 266.304
R648 gnd.n768 gnd.t78 266.304
R649 gnd.n880 gnd.n877 261.897
R650 gnd.n646 gnd.n643 261.897
R651 gnd.n47 gnd.n46 261.896
R652 gnd.n400 gnd.n399 261.896
R653 gnd.n880 gnd.n879 261.896
R654 gnd.n646 gnd.n645 261.896
R655 gnd.n530 gnd.n529 261.896
R656 gnd.n770 gnd.n769 261.896
R657 gnd.n52 gnd.t37 201.075
R658 gnd.n324 gnd.t44 201.075
R659 gnd.n506 gnd.t114 201.075
R660 gnd.n560 gnd.t115 201.075
R661 gnd.n796 gnd.t31 201.075
R662 gnd.n853 gnd.t30 201.075
R663 gnd.n73 gnd.t26 177.419
R664 gnd.n142 gnd.t28 177.419
R665 gnd.n106 gnd.t76 177.419
R666 gnd.n345 gnd.t46 177.419
R667 gnd.n633 gnd.t103 177.419
R668 gnd.n597 gnd.t107 177.419
R669 gnd.n459 gnd.t105 177.419
R670 gnd.n537 gnd.t104 177.419
R671 gnd.n657 gnd.t36 177.419
R672 gnd.n812 gnd.t133 177.419
R673 gnd.n834 gnd.t10 177.419
R674 gnd.n758 gnd.t52 177.419
R675 gnd.n79 gnd.t85 153.763
R676 gnd.n149 gnd.t48 153.763
R677 gnd.n113 gnd.t134 153.763
R678 gnd.n351 gnd.t93 153.763
R679 gnd.n639 gnd.t90 153.763
R680 gnd.n478 gnd.t124 153.763
R681 gnd.n465 gnd.t118 153.763
R682 gnd.n419 gnd.t97 153.763
R683 gnd.n651 gnd.t79 153.763
R684 gnd.n701 gnd.t39 153.763
R685 gnd.n714 gnd.t140 153.763
R686 gnd.n764 gnd.t82 153.763
R687 gnd.n58 gnd.t24 130.107
R688 gnd.n127 gnd.t138 130.107
R689 gnd.n91 gnd.t72 130.107
R690 gnd.n330 gnd.t131 130.107
R691 gnd.n620 gnd.t106 130.107
R692 gnd.n497 gnd.t101 130.107
R693 gnd.n565 gnd.t127 130.107
R694 gnd.n552 gnd.t125 130.107
R695 gnd.n669 gnd.t9 130.107
R696 gnd.n682 gnd.t74 130.107
R697 gnd.n846 gnd.t55 130.107
R698 gnd.n745 gnd.t4 130.107
R699 gnd.n64 gnd.t65 106.451
R700 gnd.n133 gnd.t40 106.451
R701 gnd.n97 gnd.t42 106.451
R702 gnd.n336 gnd.t2 106.451
R703 gnd.n515 gnd.t119 106.451
R704 gnd.n491 gnd.t116 106.451
R705 gnd.n450 gnd.t113 106.451
R706 gnd.n546 gnd.t117 106.451
R707 gnd.n664 gnd.t56 106.451
R708 gnd.n688 gnd.t137 106.451
R709 gnd.n726 gnd.t0 106.451
R710 gnd.n862 gnd.t11 106.451
R711 gnd.n157 gnd.t61 82.795
R712 gnd.n121 gnd.t50 82.795
R713 gnd.n587 gnd.t109 82.795
R714 gnd.n471 gnd.t102 82.795
R715 gnd.n707 gnd.t67 82.795
R716 gnd.n823 gnd.t58 82.795
R717 gnd.n648 gnd.t91 79.155
R718 gnd.n882 gnd.t83 79.155
R719 gnd.n397 gnd.t95 76.078
R720 gnd.n415 gnd.t98 76.078
R721 gnd.n767 gnd.t80 76.078
R722 gnd.n397 gnd.n396 61.681
R723 gnd.n48 gnd.n45 60.192
R724 gnd.n67 gnd.t63 59.139
R725 gnd.n136 gnd.t20 59.139
R726 gnd.n100 gnd.t59 59.139
R727 gnd.n339 gnd.t12 59.139
R728 gnd.n628 gnd.t126 59.139
R729 gnd.n602 gnd.t122 59.139
R730 gnd.n453 gnd.t121 59.139
R731 gnd.n543 gnd.t111 59.139
R732 gnd.n781 gnd.t23 59.139
R733 gnd.n807 gnd.t68 59.139
R734 gnd.n839 gnd.t17 59.139
R735 gnd.n753 gnd.t136 59.139
R736 gnd.n55 gnd.t70 35.483
R737 gnd.n124 gnd.t7 35.483
R738 gnd.n88 gnd.t141 35.483
R739 gnd.n327 gnd.t53 35.483
R740 gnd.n617 gnd.t128 35.483
R741 gnd.n500 gnd.t108 35.483
R742 gnd.n443 gnd.t123 35.483
R743 gnd.n436 gnd.t100 35.483
R744 gnd.n791 gnd.t6 35.483
R745 gnd.n679 gnd.t75 35.483
R746 gnd.n734 gnd.t14 35.483
R747 gnd.n742 gnd.t57 35.483
R748 gnd.n45 gnd.n44 29.884
R749 gnd.n398 gnd.n397 29.884
R750 gnd.n416 gnd.n415 29.884
R751 gnd.n768 gnd.n767 29.884
R752 gnd.n42 gnd.n40 25.6
R753 gnd.n40 gnd.n38 25.6
R754 gnd.n38 gnd.n36 25.6
R755 gnd.n36 gnd.n34 25.6
R756 gnd.n34 gnd.n32 25.6
R757 gnd.n32 gnd.n30 25.6
R758 gnd.n30 gnd.n28 25.6
R759 gnd.n28 gnd.n26 25.6
R760 gnd.n26 gnd.n24 25.6
R761 gnd.n24 gnd.n22 25.6
R762 gnd.n22 gnd.n20 25.6
R763 gnd.n20 gnd.n18 25.6
R764 gnd.n18 gnd.n16 25.6
R765 gnd.n16 gnd.n14 25.6
R766 gnd.n14 gnd.n12 25.6
R767 gnd.n12 gnd.n10 25.6
R768 gnd.n10 gnd.n8 25.6
R769 gnd.n8 gnd.n6 25.6
R770 gnd.n6 gnd.n4 25.6
R771 gnd.n4 gnd.n3 25.6
R772 gnd.n3 gnd.n2 25.6
R773 gnd.n355 gnd.n354 25.6
R774 gnd.n356 gnd.n355 25.6
R775 gnd.n358 gnd.n356 25.6
R776 gnd.n360 gnd.n358 25.6
R777 gnd.n362 gnd.n360 25.6
R778 gnd.n364 gnd.n362 25.6
R779 gnd.n366 gnd.n364 25.6
R780 gnd.n368 gnd.n366 25.6
R781 gnd.n370 gnd.n368 25.6
R782 gnd.n372 gnd.n370 25.6
R783 gnd.n374 gnd.n372 25.6
R784 gnd.n376 gnd.n374 25.6
R785 gnd.n378 gnd.n376 25.6
R786 gnd.n380 gnd.n378 25.6
R787 gnd.n382 gnd.n380 25.6
R788 gnd.n384 gnd.n382 25.6
R789 gnd.n386 gnd.n384 25.6
R790 gnd.n388 gnd.n386 25.6
R791 gnd.n390 gnd.n388 25.6
R792 gnd.n392 gnd.n390 25.6
R793 gnd.n394 gnd.n392 25.6
R794 gnd.n528 gnd.n526 25.6
R795 gnd.n526 gnd.n524 25.6
R796 gnd.n524 gnd.n522 25.6
R797 gnd.n522 gnd.n519 25.6
R798 gnd.n519 gnd.n517 25.6
R799 gnd.n517 gnd.n514 25.6
R800 gnd.n514 gnd.n512 25.6
R801 gnd.n512 gnd.n510 25.6
R802 gnd.n510 gnd.n508 25.6
R803 gnd.n508 gnd.n505 25.6
R804 gnd.n505 gnd.n502 25.6
R805 gnd.n502 gnd.n499 25.6
R806 gnd.n499 gnd.n496 25.6
R807 gnd.n496 gnd.n493 25.6
R808 gnd.n493 gnd.n490 25.6
R809 gnd.n490 gnd.n488 25.6
R810 gnd.n488 gnd.n485 25.6
R811 gnd.n485 gnd.n483 25.6
R812 gnd.n483 gnd.n480 25.6
R813 gnd.n480 gnd.n477 25.6
R814 gnd.n477 gnd.n475 25.6
R815 gnd.n475 gnd.n473 25.6
R816 gnd.n473 gnd.n470 25.6
R817 gnd.n470 gnd.n467 25.6
R818 gnd.n467 gnd.n464 25.6
R819 gnd.n464 gnd.n461 25.6
R820 gnd.n461 gnd.n458 25.6
R821 gnd.n458 gnd.n455 25.6
R822 gnd.n455 gnd.n452 25.6
R823 gnd.n452 gnd.n449 25.6
R824 gnd.n449 gnd.n447 25.6
R825 gnd.n447 gnd.n445 25.6
R826 gnd.n445 gnd.n442 25.6
R827 gnd.n442 gnd.n440 25.6
R828 gnd.n440 gnd.n438 25.6
R829 gnd.n438 gnd.n435 25.6
R830 gnd.n435 gnd.n433 25.6
R831 gnd.n433 gnd.n431 25.6
R832 gnd.n431 gnd.n429 25.6
R833 gnd.n429 gnd.n427 25.6
R834 gnd.n427 gnd.n425 25.6
R835 gnd.n425 gnd.n423 25.6
R836 gnd.n423 gnd.n421 25.6
R837 gnd.n641 gnd.n638 25.6
R838 gnd.n638 gnd.n635 25.6
R839 gnd.n635 gnd.n632 25.6
R840 gnd.n632 gnd.n630 25.6
R841 gnd.n630 gnd.n627 25.6
R842 gnd.n627 gnd.n625 25.6
R843 gnd.n625 gnd.n622 25.6
R844 gnd.n622 gnd.n619 25.6
R845 gnd.n619 gnd.n616 25.6
R846 gnd.n616 gnd.n614 25.6
R847 gnd.n614 gnd.n612 25.6
R848 gnd.n612 gnd.n610 25.6
R849 gnd.n610 gnd.n608 25.6
R850 gnd.n608 gnd.n606 25.6
R851 gnd.n606 gnd.n604 25.6
R852 gnd.n604 gnd.n601 25.6
R853 gnd.n601 gnd.n599 25.6
R854 gnd.n599 gnd.n596 25.6
R855 gnd.n596 gnd.n594 25.6
R856 gnd.n594 gnd.n592 25.6
R857 gnd.n592 gnd.n589 25.6
R858 gnd.n589 gnd.n586 25.6
R859 gnd.n586 gnd.n584 25.6
R860 gnd.n584 gnd.n582 25.6
R861 gnd.n582 gnd.n580 25.6
R862 gnd.n580 gnd.n578 25.6
R863 gnd.n578 gnd.n576 25.6
R864 gnd.n576 gnd.n574 25.6
R865 gnd.n574 gnd.n572 25.6
R866 gnd.n572 gnd.n570 25.6
R867 gnd.n570 gnd.n567 25.6
R868 gnd.n567 gnd.n564 25.6
R869 gnd.n564 gnd.n562 25.6
R870 gnd.n562 gnd.n559 25.6
R871 gnd.n559 gnd.n556 25.6
R872 gnd.n556 gnd.n554 25.6
R873 gnd.n554 gnd.n551 25.6
R874 gnd.n551 gnd.n548 25.6
R875 gnd.n548 gnd.n545 25.6
R876 gnd.n545 gnd.n542 25.6
R877 gnd.n542 gnd.n539 25.6
R878 gnd.n539 gnd.n536 25.6
R879 gnd.n536 gnd.n533 25.6
R880 gnd.n656 gnd.n653 25.6
R881 gnd.n659 gnd.n656 25.6
R882 gnd.n661 gnd.n659 25.6
R883 gnd.n663 gnd.n661 25.6
R884 gnd.n666 gnd.n663 25.6
R885 gnd.n668 gnd.n666 25.6
R886 gnd.n671 gnd.n668 25.6
R887 gnd.n673 gnd.n671 25.6
R888 gnd.n676 gnd.n673 25.6
R889 gnd.n678 gnd.n676 25.6
R890 gnd.n681 gnd.n678 25.6
R891 gnd.n684 gnd.n681 25.6
R892 gnd.n687 gnd.n684 25.6
R893 gnd.n690 gnd.n687 25.6
R894 gnd.n692 gnd.n690 25.6
R895 gnd.n695 gnd.n692 25.6
R896 gnd.n697 gnd.n695 25.6
R897 gnd.n700 gnd.n697 25.6
R898 gnd.n703 gnd.n700 25.6
R899 gnd.n706 gnd.n703 25.6
R900 gnd.n709 gnd.n706 25.6
R901 gnd.n711 gnd.n709 25.6
R902 gnd.n713 gnd.n711 25.6
R903 gnd.n716 gnd.n713 25.6
R904 gnd.n718 gnd.n716 25.6
R905 gnd.n720 gnd.n718 25.6
R906 gnd.n723 gnd.n720 25.6
R907 gnd.n725 gnd.n723 25.6
R908 gnd.n728 gnd.n725 25.6
R909 gnd.n731 gnd.n728 25.6
R910 gnd.n733 gnd.n731 25.6
R911 gnd.n736 gnd.n733 25.6
R912 gnd.n739 gnd.n736 25.6
R913 gnd.n741 gnd.n739 25.6
R914 gnd.n744 gnd.n741 25.6
R915 gnd.n747 gnd.n744 25.6
R916 gnd.n750 gnd.n747 25.6
R917 gnd.n752 gnd.n750 25.6
R918 gnd.n755 gnd.n752 25.6
R919 gnd.n757 gnd.n755 25.6
R920 gnd.n760 gnd.n757 25.6
R921 gnd.n763 gnd.n760 25.6
R922 gnd.n766 gnd.n763 25.6
R923 gnd.n775 gnd.n773 25.6
R924 gnd.n777 gnd.n775 25.6
R925 gnd.n780 gnd.n777 25.6
R926 gnd.n783 gnd.n780 25.6
R927 gnd.n785 gnd.n783 25.6
R928 gnd.n788 gnd.n785 25.6
R929 gnd.n790 gnd.n788 25.6
R930 gnd.n793 gnd.n790 25.6
R931 gnd.n795 gnd.n793 25.6
R932 gnd.n798 gnd.n795 25.6
R933 gnd.n800 gnd.n798 25.6
R934 gnd.n802 gnd.n800 25.6
R935 gnd.n804 gnd.n802 25.6
R936 gnd.n806 gnd.n804 25.6
R937 gnd.n809 gnd.n806 25.6
R938 gnd.n811 gnd.n809 25.6
R939 gnd.n814 gnd.n811 25.6
R940 gnd.n816 gnd.n814 25.6
R941 gnd.n818 gnd.n816 25.6
R942 gnd.n820 gnd.n818 25.6
R943 gnd.n822 gnd.n820 25.6
R944 gnd.n825 gnd.n822 25.6
R945 gnd.n828 gnd.n825 25.6
R946 gnd.n830 gnd.n828 25.6
R947 gnd.n833 gnd.n830 25.6
R948 gnd.n836 gnd.n833 25.6
R949 gnd.n838 gnd.n836 25.6
R950 gnd.n841 gnd.n838 25.6
R951 gnd.n843 gnd.n841 25.6
R952 gnd.n845 gnd.n843 25.6
R953 gnd.n848 gnd.n845 25.6
R954 gnd.n850 gnd.n848 25.6
R955 gnd.n852 gnd.n850 25.6
R956 gnd.n855 gnd.n852 25.6
R957 gnd.n857 gnd.n855 25.6
R958 gnd.n859 gnd.n857 25.6
R959 gnd.n861 gnd.n859 25.6
R960 gnd.n864 gnd.n861 25.6
R961 gnd.n866 gnd.n864 25.6
R962 gnd.n869 gnd.n866 25.6
R963 gnd.n871 gnd.n869 25.6
R964 gnd.n873 gnd.n871 25.6
R965 gnd.n875 gnd.n873 25.6
R966 gnd.n303 gnd.n302 23.571
R967 gnd.n303 gnd.t35 23.571
R968 gnd.n293 gnd.t27 23.571
R969 gnd.n293 gnd.t64 23.571
R970 gnd.n284 gnd.t66 23.571
R971 gnd.n284 gnd.t25 23.571
R972 gnd.n275 gnd.t71 23.571
R973 gnd.n275 gnd.t38 23.571
R974 gnd.n266 gnd.t8 23.571
R975 gnd.n266 gnd.t139 23.571
R976 gnd.n257 gnd.t41 23.571
R977 gnd.n257 gnd.t21 23.571
R978 gnd.n248 gnd.t29 23.571
R979 gnd.n248 gnd.t16 23.571
R980 gnd.n239 gnd.t49 23.571
R981 gnd.n239 gnd.t62 23.571
R982 gnd.n160 gnd.t51 23.571
R983 gnd.n160 gnd.t135 23.571
R984 gnd.n169 gnd.t130 23.571
R985 gnd.n169 gnd.t77 23.571
R986 gnd.n178 gnd.t60 23.571
R987 gnd.n178 gnd.t43 23.571
R988 gnd.n187 gnd.t73 23.571
R989 gnd.n187 gnd.t142 23.571
R990 gnd.n196 gnd.t45 23.571
R991 gnd.n196 gnd.t54 23.571
R992 gnd.n205 gnd.t132 23.571
R993 gnd.n205 gnd.t3 23.571
R994 gnd.n214 gnd.t13 23.571
R995 gnd.n214 gnd.t47 23.571
R996 gnd.n223 gnd.t33 23.571
R997 gnd.n223 gnd.t94 23.571
R998 gnd.n44 gnd.n43 21.891
R999 gnd.n418 gnd.n416 21.891
R1000 gnd.n771 gnd.n768 21.891
R1001 gnd.n43 gnd.n42 21.458
R1002 gnd.n396 gnd.n394 21.458
R1003 gnd.n642 gnd.n528 21.458
R1004 gnd.n421 gnd.n418 21.458
R1005 gnd.n642 gnd.n641 21.458
R1006 gnd.n533 gnd.n531 21.458
R1007 gnd.n653 gnd.n650 21.458
R1008 gnd.n876 gnd.n766 21.458
R1009 gnd.n773 gnd.n771 21.458
R1010 gnd.n876 gnd.n875 21.458
R1011 gnd.n401 gnd.n398 20.402
R1012 gnd.n881 gnd.n880 15.303
R1013 gnd.n647 gnd.n646 15.303
R1014 gnd.n76 gnd.t34 11.827
R1015 gnd.n145 gnd.t15 11.827
R1016 gnd.n109 gnd.t129 11.827
R1017 gnd.n348 gnd.t32 11.827
R1018 gnd.n636 gnd.t110 11.827
R1019 gnd.n481 gnd.t99 11.827
R1020 gnd.n462 gnd.t112 11.827
R1021 gnd.n534 gnd.t120 11.827
R1022 gnd.n654 gnd.t19 11.827
R1023 gnd.n698 gnd.t18 11.827
R1024 gnd.n831 gnd.t1 11.827
R1025 gnd.n761 gnd.t69 11.827
R1026 gnd.n883 gnd.n882 8.434
R1027 gnd.n883 gnd.n648 8.434
R1028 gnd.n309 gnd.n304 8.032
R1029 gnd.n299 gnd.n294 8.032
R1030 gnd.n290 gnd.n285 8.032
R1031 gnd.n281 gnd.n276 8.032
R1032 gnd.n272 gnd.n267 8.032
R1033 gnd.n263 gnd.n258 8.032
R1034 gnd.n254 gnd.n249 8.032
R1035 gnd.n245 gnd.n240 8.032
R1036 gnd.n166 gnd.n161 8.032
R1037 gnd.n175 gnd.n170 8.032
R1038 gnd.n184 gnd.n179 8.032
R1039 gnd.n193 gnd.n188 8.032
R1040 gnd.n202 gnd.n197 8.032
R1041 gnd.n211 gnd.n206 8.032
R1042 gnd.n220 gnd.n215 8.032
R1043 gnd.n229 gnd.n224 8.032
R1044 gnd.n81 gnd.n78 5.06
R1045 gnd.n78 gnd.n75 5.06
R1046 gnd.n75 gnd.n72 5.06
R1047 gnd.n72 gnd.n69 5.06
R1048 gnd.n69 gnd.n66 5.06
R1049 gnd.n66 gnd.n63 5.06
R1050 gnd.n63 gnd.n60 5.06
R1051 gnd.n60 gnd.n57 5.06
R1052 gnd.n57 gnd.n54 5.06
R1053 gnd.n54 gnd.n51 5.06
R1054 gnd.n129 gnd.n126 5.06
R1055 gnd.n132 gnd.n129 5.06
R1056 gnd.n135 gnd.n132 5.06
R1057 gnd.n138 gnd.n135 5.06
R1058 gnd.n141 gnd.n138 5.06
R1059 gnd.n144 gnd.n141 5.06
R1060 gnd.n147 gnd.n144 5.06
R1061 gnd.n151 gnd.n147 5.06
R1062 gnd.n155 gnd.n151 5.06
R1063 gnd.n159 gnd.n155 5.06
R1064 gnd.n123 gnd.n119 5.06
R1065 gnd.n119 gnd.n115 5.06
R1066 gnd.n115 gnd.n111 5.06
R1067 gnd.n111 gnd.n108 5.06
R1068 gnd.n108 gnd.n105 5.06
R1069 gnd.n105 gnd.n102 5.06
R1070 gnd.n102 gnd.n99 5.06
R1071 gnd.n99 gnd.n96 5.06
R1072 gnd.n96 gnd.n93 5.06
R1073 gnd.n93 gnd.n90 5.06
R1074 gnd.n326 gnd.n323 5.06
R1075 gnd.n329 gnd.n326 5.06
R1076 gnd.n332 gnd.n329 5.06
R1077 gnd.n335 gnd.n332 5.06
R1078 gnd.n338 gnd.n335 5.06
R1079 gnd.n341 gnd.n338 5.06
R1080 gnd.n344 gnd.n341 5.06
R1081 gnd.n347 gnd.n344 5.06
R1082 gnd.n350 gnd.n347 5.06
R1083 gnd.n353 gnd.n350 5.06
R1084 gnd.n402 gnd.n353 4.018
R1085 gnd.n82 gnd.n81 3.944
R1086 gnd.n306 gnd.n305 3.85
R1087 gnd.n296 gnd.n295 3.85
R1088 gnd.n287 gnd.n286 3.85
R1089 gnd.n278 gnd.n277 3.85
R1090 gnd.n269 gnd.n268 3.85
R1091 gnd.n260 gnd.n259 3.85
R1092 gnd.n251 gnd.n250 3.85
R1093 gnd.n242 gnd.n241 3.85
R1094 gnd.n163 gnd.n162 3.85
R1095 gnd.n172 gnd.n171 3.85
R1096 gnd.n181 gnd.n180 3.85
R1097 gnd.n190 gnd.n189 3.85
R1098 gnd.n199 gnd.n198 3.85
R1099 gnd.n208 gnd.n207 3.85
R1100 gnd.n217 gnd.n216 3.85
R1101 gnd.n226 gnd.n225 3.85
R1102 gnd.n319 gnd.n159 2.53
R1103 gnd.n319 gnd.n123 2.53
R1104 gnd.n85 gnd.n84 2.264
R1105 gnd.n304 gnd.n303 1.601
R1106 gnd.n294 gnd.n293 1.601
R1107 gnd.n285 gnd.n284 1.601
R1108 gnd.n276 gnd.n275 1.601
R1109 gnd.n267 gnd.n266 1.601
R1110 gnd.n258 gnd.n257 1.601
R1111 gnd.n249 gnd.n248 1.601
R1112 gnd.n240 gnd.n239 1.601
R1113 gnd.n161 gnd.n160 1.601
R1114 gnd.n170 gnd.n169 1.601
R1115 gnd.n179 gnd.n178 1.601
R1116 gnd.n188 gnd.n187 1.601
R1117 gnd.n197 gnd.n196 1.601
R1118 gnd.n206 gnd.n205 1.601
R1119 gnd.n215 gnd.n214 1.601
R1120 gnd.n224 gnd.n223 1.601
R1121 gnd.n82 gnd.n48 1.116
R1122 gnd.n402 gnd.n401 1.041
R1123 gnd.n884 gnd.n883 0.83
R1124 gnd.n312 gnd.n311 0.763
R1125 gnd.n232 gnd.n231 0.763
R1126 gnd.n86 gnd.n85 0.654
R1127 gnd.n310 gnd.n309 0.617
R1128 gnd.n300 gnd.n299 0.617
R1129 gnd.n291 gnd.n290 0.617
R1130 gnd.n282 gnd.n281 0.617
R1131 gnd.n273 gnd.n272 0.617
R1132 gnd.n264 gnd.n263 0.617
R1133 gnd.n255 gnd.n254 0.617
R1134 gnd.n246 gnd.n245 0.617
R1135 gnd.n167 gnd.n166 0.617
R1136 gnd.n176 gnd.n175 0.617
R1137 gnd.n185 gnd.n184 0.617
R1138 gnd.n194 gnd.n193 0.617
R1139 gnd.n203 gnd.n202 0.617
R1140 gnd.n212 gnd.n211 0.617
R1141 gnd.n221 gnd.n220 0.617
R1142 gnd.n230 gnd.n229 0.617
R1143 gnd.n902 gnd.n901 0.598
R1144 gnd.n895 gnd.n894 0.594
R1145 gnd.n312 gnd.n301 0.576
R1146 gnd.n313 gnd.n292 0.576
R1147 gnd.n314 gnd.n283 0.576
R1148 gnd.n315 gnd.n274 0.576
R1149 gnd.n316 gnd.n265 0.576
R1150 gnd.n317 gnd.n256 0.576
R1151 gnd.n318 gnd.n247 0.576
R1152 gnd.n238 gnd.n168 0.576
R1153 gnd.n237 gnd.n177 0.576
R1154 gnd.n236 gnd.n186 0.576
R1155 gnd.n235 gnd.n195 0.576
R1156 gnd.n234 gnd.n204 0.576
R1157 gnd.n233 gnd.n213 0.576
R1158 gnd.n232 gnd.n222 0.576
R1159 gnd.n894 gnd.n408 0.354
R1160 gnd.n407 gnd.n406 0.291
R1161 gnd.n405 gnd.n404 0.291
R1162 gnd.n893 gnd.n892 0.236
R1163 gnd.n900 gnd.n899 0.236
R1164 gnd.n903 gnd.n320 0.221
R1165 gnd.n87 gnd.n0 0.221
R1166 gnd.n86 gnd.n83 0.221
R1167 gnd.n902 gnd.n403 0.221
R1168 gnd.n892 gnd.n890 0.212
R1169 gnd.n901 gnd.n900 0.212
R1170 gnd.n893 gnd.n409 0.208
R1171 gnd.n898 gnd.n897 0.208
R1172 gnd.n881 gnd.n876 0.203
R1173 gnd.n647 gnd.n642 0.203
R1174 gnd.n886 gnd.n885 0.191
R1175 gnd.n313 gnd.n312 0.187
R1176 gnd.n314 gnd.n313 0.187
R1177 gnd.n315 gnd.n314 0.187
R1178 gnd.n316 gnd.n315 0.187
R1179 gnd.n317 gnd.n316 0.187
R1180 gnd.n318 gnd.n317 0.187
R1181 gnd.n238 gnd.n237 0.187
R1182 gnd.n237 gnd.n236 0.187
R1183 gnd.n236 gnd.n235 0.187
R1184 gnd.n235 gnd.n234 0.187
R1185 gnd.n234 gnd.n233 0.187
R1186 gnd.n233 gnd.n232 0.187
R1187 gnd.n887 gnd.n886 0.156
R1188 gnd.n888 gnd.n887 0.156
R1189 gnd.n889 gnd.n888 0.156
R1190 gnd.n890 gnd.n889 0.156
R1191 gnd.n894 gnd.n893 0.156
R1192 gnd.n898 gnd.n895 0.156
R1193 gnd.n899 gnd.n898 0.156
R1194 gnd.n886 gnd.n414 0.145
R1195 gnd.n887 gnd.n413 0.145
R1196 gnd.n888 gnd.n412 0.145
R1197 gnd.n889 gnd.n411 0.145
R1198 gnd.n890 gnd.n410 0.145
R1199 gnd.n901 gnd.n405 0.145
R1200 gnd.n87 gnd.n86 0.125
R1201 gnd.n903 gnd.n902 0.125
R1202 gnd.n882 gnd.n881 0.11
R1203 gnd.n648 gnd.n647 0.11
R1204 gnd.n309 gnd.n308 0.098
R1205 gnd.n299 gnd.n298 0.098
R1206 gnd.n290 gnd.n289 0.098
R1207 gnd.n281 gnd.n280 0.098
R1208 gnd.n272 gnd.n271 0.098
R1209 gnd.n263 gnd.n262 0.098
R1210 gnd.n254 gnd.n253 0.098
R1211 gnd.n245 gnd.n244 0.098
R1212 gnd.n166 gnd.n165 0.098
R1213 gnd.n175 gnd.n174 0.098
R1214 gnd.n184 gnd.n183 0.098
R1215 gnd.n193 gnd.n192 0.098
R1216 gnd.n202 gnd.n201 0.098
R1217 gnd.n211 gnd.n210 0.098
R1218 gnd.n220 gnd.n219 0.098
R1219 gnd.n229 gnd.n228 0.098
R1220 gnd.n319 gnd.n318 0.093
R1221 gnd.n319 gnd.n238 0.093
R1222 gnd.n897 gnd.n896 0.086
R1223 gnd gnd.n87 0.085
R1224 gnd.n320 gnd.n319 0.062
R1225 gnd.n885 gnd.n884 0.056
R1226 gnd.n892 gnd.n891 0.053
R1227 gnd.n900 gnd.n407 0.053
R1228 gnd.n83 gnd.n82 0.049
R1229 gnd.n403 gnd.n402 0.049
R1230 gnd.n311 gnd.n310 0.039
R1231 gnd.n301 gnd.n300 0.039
R1232 gnd.n292 gnd.n291 0.039
R1233 gnd.n283 gnd.n282 0.039
R1234 gnd.n274 gnd.n273 0.039
R1235 gnd.n265 gnd.n264 0.039
R1236 gnd.n256 gnd.n255 0.039
R1237 gnd.n247 gnd.n246 0.039
R1238 gnd.n168 gnd.n167 0.039
R1239 gnd.n177 gnd.n176 0.039
R1240 gnd.n186 gnd.n185 0.039
R1241 gnd.n195 gnd.n194 0.039
R1242 gnd.n204 gnd.n203 0.039
R1243 gnd.n213 gnd.n212 0.039
R1244 gnd.n222 gnd.n221 0.039
R1245 gnd.n231 gnd.n230 0.039
R1246 gnd gnd.n903 0.039
R1247 gnd.n85 gnd.t5 0.03
R1248 gnd.n84 gnd.t22 0.03
R1249 gnd.n307 gnd.n306 0.008
R1250 gnd.n297 gnd.n296 0.008
R1251 gnd.n288 gnd.n287 0.008
R1252 gnd.n279 gnd.n278 0.008
R1253 gnd.n270 gnd.n269 0.008
R1254 gnd.n261 gnd.n260 0.008
R1255 gnd.n252 gnd.n251 0.008
R1256 gnd.n243 gnd.n242 0.008
R1257 gnd.n164 gnd.n163 0.008
R1258 gnd.n173 gnd.n172 0.008
R1259 gnd.n182 gnd.n181 0.008
R1260 gnd.n191 gnd.n190 0.008
R1261 gnd.n200 gnd.n199 0.008
R1262 gnd.n209 gnd.n208 0.008
R1263 gnd.n218 gnd.n217 0.008
R1264 gnd.n227 gnd.n226 0.008
R1265 gnd.n308 gnd.n307 0.001
R1266 gnd.n298 gnd.n297 0.001
R1267 gnd.n289 gnd.n288 0.001
R1268 gnd.n280 gnd.n279 0.001
R1269 gnd.n271 gnd.n270 0.001
R1270 gnd.n262 gnd.n261 0.001
R1271 gnd.n253 gnd.n252 0.001
R1272 gnd.n244 gnd.n243 0.001
R1273 gnd.n165 gnd.n164 0.001
R1274 gnd.n174 gnd.n173 0.001
R1275 gnd.n183 gnd.n182 0.001
R1276 gnd.n192 gnd.n191 0.001
R1277 gnd.n201 gnd.n200 0.001
R1278 gnd.n210 gnd.n209 0.001
R1279 gnd.n219 gnd.n218 0.001
R1280 gnd.n228 gnd.n227 0.001
R1281 in.n0 in.t3 231.02
R1282 in.n14 in.t19 231.02
R1283 in.n1 in.t1 230.836
R1284 in.n3 in.t12 230.836
R1285 in.n5 in.t13 230.836
R1286 in.n7 in.t18 230.836
R1287 in.n9 in.t20 230.836
R1288 in.n11 in.t26 230.836
R1289 in.n13 in.t29 230.836
R1290 in.n0 in.t16 230.836
R1291 in.n2 in.t22 230.836
R1292 in.n4 in.t24 230.836
R1293 in.n6 in.t28 230.836
R1294 in.n8 in.t8 230.836
R1295 in.n10 in.t10 230.836
R1296 in.n12 in.t15 230.836
R1297 in.n27 in.t23 230.836
R1298 in.n26 in.t6 230.836
R1299 in.n25 in.t17 230.836
R1300 in.n24 in.t27 230.836
R1301 in.n23 in.t4 230.836
R1302 in.n22 in.t2 230.836
R1303 in.n21 in.t11 230.836
R1304 in.n20 in.t21 230.836
R1305 in.n19 in.t0 230.836
R1306 in.n18 in.t7 230.836
R1307 in.n17 in.t5 230.836
R1308 in.n16 in.t14 230.836
R1309 in.n15 in.t25 230.836
R1310 in.n14 in.t9 230.836
R1311 in.n28 in.n27 0.479
R1312 in.n28 in.n13 0.387
R1313 in.n1 in.n0 0.184
R1314 in.n2 in.n1 0.184
R1315 in.n3 in.n2 0.184
R1316 in.n4 in.n3 0.184
R1317 in.n5 in.n4 0.184
R1318 in.n6 in.n5 0.184
R1319 in.n7 in.n6 0.184
R1320 in.n8 in.n7 0.184
R1321 in.n9 in.n8 0.184
R1322 in.n10 in.n9 0.184
R1323 in.n11 in.n10 0.184
R1324 in.n12 in.n11 0.184
R1325 in.n13 in.n12 0.184
R1326 in.n15 in.n14 0.184
R1327 in.n16 in.n15 0.184
R1328 in.n17 in.n16 0.184
R1329 in.n18 in.n17 0.184
R1330 in.n19 in.n18 0.184
R1331 in.n20 in.n19 0.184
R1332 in.n21 in.n20 0.184
R1333 in.n22 in.n21 0.184
R1334 in.n23 in.n22 0.184
R1335 in.n24 in.n23 0.184
R1336 in.n25 in.n24 0.184
R1337 in.n26 in.n25 0.184
R1338 in.n27 in.n26 0.184
R1339 in in.n28 0.146
R1340 Vctrl.n14 Vctrl.t11 231.02
R1341 Vctrl.n0 Vctrl.t3 231.02
R1342 Vctrl.n27 Vctrl.t8 230.837
R1343 Vctrl.n13 Vctrl.t2 230.836
R1344 Vctrl.n11 Vctrl.t5 230.836
R1345 Vctrl.n9 Vctrl.t10 230.836
R1346 Vctrl.n7 Vctrl.t4 230.836
R1347 Vctrl.n5 Vctrl.t17 230.836
R1348 Vctrl.n3 Vctrl.t20 230.836
R1349 Vctrl.n1 Vctrl.t25 230.836
R1350 Vctrl.n14 Vctrl.t23 230.836
R1351 Vctrl.n15 Vctrl.t6 230.836
R1352 Vctrl.n16 Vctrl.t16 230.836
R1353 Vctrl.n17 Vctrl.t27 230.836
R1354 Vctrl.n18 Vctrl.t14 230.836
R1355 Vctrl.n19 Vctrl.t26 230.836
R1356 Vctrl.n20 Vctrl.t9 230.836
R1357 Vctrl.n21 Vctrl.t21 230.836
R1358 Vctrl.n22 Vctrl.t30 230.836
R1359 Vctrl.n23 Vctrl.t18 230.836
R1360 Vctrl.n24 Vctrl.t29 230.836
R1361 Vctrl.n25 Vctrl.t12 230.836
R1362 Vctrl.n26 Vctrl.t0 230.836
R1363 Vctrl.n12 Vctrl.t15 230.836
R1364 Vctrl.n10 Vctrl.t22 230.836
R1365 Vctrl.n8 Vctrl.t24 230.836
R1366 Vctrl.n6 Vctrl.t28 230.836
R1367 Vctrl.n4 Vctrl.t7 230.836
R1368 Vctrl.n2 Vctrl.t1 230.836
R1369 Vctrl.n0 Vctrl.t13 230.836
R1370 Vctrl.n28 Vctrl.n27 0.563
R1371 Vctrl.n28 Vctrl.n13 0.471
R1372 Vctrl.n27 Vctrl.n26 0.184
R1373 Vctrl.n26 Vctrl.n25 0.184
R1374 Vctrl.n25 Vctrl.n24 0.184
R1375 Vctrl.n24 Vctrl.n23 0.184
R1376 Vctrl.n23 Vctrl.n22 0.184
R1377 Vctrl.n22 Vctrl.n21 0.184
R1378 Vctrl.n21 Vctrl.n20 0.184
R1379 Vctrl.n20 Vctrl.n19 0.184
R1380 Vctrl.n19 Vctrl.n18 0.184
R1381 Vctrl.n18 Vctrl.n17 0.184
R1382 Vctrl.n17 Vctrl.n16 0.184
R1383 Vctrl.n16 Vctrl.n15 0.184
R1384 Vctrl.n15 Vctrl.n14 0.184
R1385 Vctrl.n13 Vctrl.n12 0.184
R1386 Vctrl.n12 Vctrl.n11 0.184
R1387 Vctrl.n11 Vctrl.n10 0.184
R1388 Vctrl.n10 Vctrl.n9 0.184
R1389 Vctrl.n9 Vctrl.n8 0.184
R1390 Vctrl.n8 Vctrl.n7 0.184
R1391 Vctrl.n7 Vctrl.n6 0.184
R1392 Vctrl.n6 Vctrl.n5 0.184
R1393 Vctrl.n5 Vctrl.n4 0.184
R1394 Vctrl.n4 Vctrl.n3 0.184
R1395 Vctrl.n3 Vctrl.n2 0.184
R1396 Vctrl.n2 Vctrl.n1 0.184
R1397 Vctrl.n1 Vctrl.n0 0.184
R1398 Vctrl.t19 Vctrl.n28 0.17
R1399 Vctrl Vctrl.t19 0.023
R1400 Vdd.n0 Vdd.t2 23.571
R1401 Vdd.n0 Vdd.t20 23.571
R1402 Vdd.n132 Vdd.t26 23.571
R1403 Vdd.n132 Vdd.t18 23.571
R1404 Vdd.n123 Vdd.t16 23.571
R1405 Vdd.n123 Vdd.t7 23.571
R1406 Vdd.n114 Vdd.t5 23.571
R1407 Vdd.n114 Vdd.t23 23.571
R1408 Vdd.n105 Vdd.t28 23.571
R1409 Vdd.n105 Vdd.t13 23.571
R1410 Vdd.n96 Vdd.t10 23.571
R1411 Vdd.n96 Vdd.t3 23.571
R1412 Vdd.n87 Vdd.t22 23.571
R1413 Vdd.n87 Vdd.t15 23.571
R1414 Vdd.n78 Vdd.t12 23.571
R1415 Vdd.n78 Vdd.t4 23.571
R1416 Vdd.n9 Vdd.t25 23.571
R1417 Vdd.n9 Vdd.t9 23.571
R1418 Vdd.n18 Vdd.t6 23.571
R1419 Vdd.n18 Vdd.t0 23.571
R1420 Vdd.n27 Vdd.t19 23.571
R1421 Vdd.n27 Vdd.t11 23.571
R1422 Vdd.n36 Vdd.t8 23.571
R1423 Vdd.n36 Vdd.t1 23.571
R1424 Vdd.n45 Vdd.t24 23.571
R1425 Vdd.n45 Vdd.t17 23.571
R1426 Vdd.n54 Vdd.t14 23.571
R1427 Vdd.n54 Vdd.t29 23.571
R1428 Vdd.n63 Vdd.t27 23.571
R1429 Vdd.n63 Vdd.t21 23.571
R1430 Vdd.n6 Vdd.n1 8.032
R1431 Vdd.n129 Vdd.n124 8.032
R1432 Vdd.n120 Vdd.n115 8.032
R1433 Vdd.n111 Vdd.n106 8.032
R1434 Vdd.n102 Vdd.n97 8.032
R1435 Vdd.n93 Vdd.n88 8.032
R1436 Vdd.n84 Vdd.n79 8.032
R1437 Vdd.n15 Vdd.n10 8.032
R1438 Vdd.n24 Vdd.n19 8.032
R1439 Vdd.n33 Vdd.n28 8.032
R1440 Vdd.n42 Vdd.n37 8.032
R1441 Vdd.n51 Vdd.n46 8.032
R1442 Vdd.n60 Vdd.n55 8.032
R1443 Vdd.n69 Vdd.n64 8.032
R1444 Vdd.n138 Vdd.n133 8.031
R1445 Vdd.n3 Vdd.n2 3.85
R1446 Vdd.n135 Vdd.n134 3.85
R1447 Vdd.n126 Vdd.n125 3.85
R1448 Vdd.n117 Vdd.n116 3.85
R1449 Vdd.n108 Vdd.n107 3.85
R1450 Vdd.n99 Vdd.n98 3.85
R1451 Vdd.n90 Vdd.n89 3.85
R1452 Vdd.n81 Vdd.n80 3.85
R1453 Vdd.n12 Vdd.n11 3.85
R1454 Vdd.n21 Vdd.n20 3.85
R1455 Vdd.n30 Vdd.n29 3.85
R1456 Vdd.n39 Vdd.n38 3.85
R1457 Vdd.n48 Vdd.n47 3.85
R1458 Vdd.n57 Vdd.n56 3.85
R1459 Vdd.n66 Vdd.n65 3.85
R1460 Vdd.n1 Vdd.n0 1.601
R1461 Vdd.n133 Vdd.n132 1.601
R1462 Vdd.n124 Vdd.n123 1.601
R1463 Vdd.n115 Vdd.n114 1.601
R1464 Vdd.n106 Vdd.n105 1.601
R1465 Vdd.n97 Vdd.n96 1.601
R1466 Vdd.n88 Vdd.n87 1.601
R1467 Vdd.n79 Vdd.n78 1.601
R1468 Vdd.n10 Vdd.n9 1.601
R1469 Vdd.n19 Vdd.n18 1.601
R1470 Vdd.n28 Vdd.n27 1.601
R1471 Vdd.n37 Vdd.n36 1.601
R1472 Vdd.n46 Vdd.n45 1.601
R1473 Vdd.n55 Vdd.n54 1.601
R1474 Vdd.n64 Vdd.n63 1.601
R1475 Vdd.n141 Vdd.n140 0.63
R1476 Vdd.n72 Vdd.n71 0.63
R1477 Vdd.n139 Vdd.n138 0.619
R1478 Vdd.n7 Vdd.n6 0.618
R1479 Vdd.n130 Vdd.n129 0.618
R1480 Vdd.n121 Vdd.n120 0.618
R1481 Vdd.n112 Vdd.n111 0.618
R1482 Vdd.n103 Vdd.n102 0.618
R1483 Vdd.n94 Vdd.n93 0.618
R1484 Vdd.n85 Vdd.n84 0.618
R1485 Vdd.n16 Vdd.n15 0.618
R1486 Vdd.n25 Vdd.n24 0.618
R1487 Vdd.n34 Vdd.n33 0.618
R1488 Vdd.n43 Vdd.n42 0.618
R1489 Vdd.n52 Vdd.n51 0.618
R1490 Vdd.n61 Vdd.n60 0.618
R1491 Vdd.n70 Vdd.n69 0.618
R1492 Vdd.n147 Vdd.n8 0.568
R1493 Vdd.n141 Vdd.n131 0.568
R1494 Vdd.n142 Vdd.n122 0.568
R1495 Vdd.n143 Vdd.n113 0.568
R1496 Vdd.n144 Vdd.n104 0.568
R1497 Vdd.n145 Vdd.n95 0.568
R1498 Vdd.n146 Vdd.n86 0.568
R1499 Vdd.n77 Vdd.n17 0.568
R1500 Vdd.n76 Vdd.n26 0.568
R1501 Vdd.n75 Vdd.n35 0.568
R1502 Vdd.n74 Vdd.n44 0.568
R1503 Vdd.n73 Vdd.n53 0.568
R1504 Vdd.n72 Vdd.n62 0.568
R1505 Vdd.n138 Vdd.n137 0.098
R1506 Vdd.n6 Vdd.n5 0.098
R1507 Vdd.n129 Vdd.n128 0.098
R1508 Vdd.n120 Vdd.n119 0.098
R1509 Vdd.n111 Vdd.n110 0.098
R1510 Vdd.n102 Vdd.n101 0.098
R1511 Vdd.n93 Vdd.n92 0.098
R1512 Vdd.n84 Vdd.n83 0.098
R1513 Vdd.n15 Vdd.n14 0.098
R1514 Vdd.n24 Vdd.n23 0.098
R1515 Vdd.n33 Vdd.n32 0.098
R1516 Vdd.n42 Vdd.n41 0.098
R1517 Vdd.n51 Vdd.n50 0.098
R1518 Vdd.n60 Vdd.n59 0.098
R1519 Vdd.n69 Vdd.n68 0.098
R1520 Vdd.n73 Vdd.n72 0.062
R1521 Vdd.n74 Vdd.n73 0.062
R1522 Vdd.n75 Vdd.n74 0.062
R1523 Vdd.n76 Vdd.n75 0.062
R1524 Vdd.n77 Vdd.n76 0.062
R1525 Vdd.n147 Vdd.n77 0.062
R1526 Vdd.n147 Vdd.n146 0.062
R1527 Vdd.n146 Vdd.n145 0.062
R1528 Vdd.n145 Vdd.n144 0.062
R1529 Vdd.n144 Vdd.n143 0.062
R1530 Vdd.n143 Vdd.n142 0.062
R1531 Vdd.n142 Vdd.n141 0.062
R1532 Vdd.t30 Vdd.n147 0.062
R1533 Vdd.n8 Vdd.n7 0.037
R1534 Vdd.n140 Vdd.n139 0.037
R1535 Vdd.n131 Vdd.n130 0.037
R1536 Vdd.n122 Vdd.n121 0.037
R1537 Vdd.n113 Vdd.n112 0.037
R1538 Vdd.n104 Vdd.n103 0.037
R1539 Vdd.n95 Vdd.n94 0.037
R1540 Vdd.n86 Vdd.n85 0.037
R1541 Vdd.n17 Vdd.n16 0.037
R1542 Vdd.n26 Vdd.n25 0.037
R1543 Vdd.n35 Vdd.n34 0.037
R1544 Vdd.n44 Vdd.n43 0.037
R1545 Vdd.n53 Vdd.n52 0.037
R1546 Vdd.n62 Vdd.n61 0.037
R1547 Vdd.n71 Vdd.n70 0.037
R1548 Vdd Vdd.t30 0.021
R1549 Vdd.n4 Vdd.n3 0.008
R1550 Vdd.n136 Vdd.n135 0.008
R1551 Vdd.n127 Vdd.n126 0.008
R1552 Vdd.n118 Vdd.n117 0.008
R1553 Vdd.n109 Vdd.n108 0.008
R1554 Vdd.n100 Vdd.n99 0.008
R1555 Vdd.n91 Vdd.n90 0.008
R1556 Vdd.n82 Vdd.n81 0.008
R1557 Vdd.n13 Vdd.n12 0.008
R1558 Vdd.n22 Vdd.n21 0.008
R1559 Vdd.n31 Vdd.n30 0.008
R1560 Vdd.n40 Vdd.n39 0.008
R1561 Vdd.n49 Vdd.n48 0.008
R1562 Vdd.n58 Vdd.n57 0.008
R1563 Vdd.n67 Vdd.n66 0.008
R1564 Vdd.n5 Vdd.n4 0.001
R1565 Vdd.n137 Vdd.n136 0.001
R1566 Vdd.n128 Vdd.n127 0.001
R1567 Vdd.n119 Vdd.n118 0.001
R1568 Vdd.n110 Vdd.n109 0.001
R1569 Vdd.n101 Vdd.n100 0.001
R1570 Vdd.n92 Vdd.n91 0.001
R1571 Vdd.n83 Vdd.n82 0.001
R1572 Vdd.n14 Vdd.n13 0.001
R1573 Vdd.n23 Vdd.n22 0.001
R1574 Vdd.n32 Vdd.n31 0.001
R1575 Vdd.n41 Vdd.n40 0.001
R1576 Vdd.n50 Vdd.n49 0.001
R1577 Vdd.n59 Vdd.n58 0.001
R1578 Vdd.n68 Vdd.n67 0.001
C8 in gnd 32.80570fF
C9 Vdd gnd 34.75249fF
C10 Vctrl gnd 38.34278fF
C11 out gnd 9.53734fF
C12 gate gnd 30.07200fF
C13 a_47_7835# gnd 26.06990fF
C14 Vdd.t2 gnd 0.00357fF
C15 Vdd.t20 gnd 0.00357fF
C16 Vdd.n0 gnd 0.00715fF
C17 Vdd.n1 gnd 0.00115fF
C18 Vdd.n2 gnd 0.00288fF
C19 Vdd.n3 gnd 0.00137fF
C20 Vdd.n4 gnd 0.00070fF
C21 Vdd.n5 gnd 0.00273fF
C22 Vdd.n6 gnd 0.00796fF
C23 Vdd.n7 gnd 0.00815fF
C24 Vdd.n8 gnd 0.01280fF
C25 Vdd.t25 gnd 0.00357fF
C26 Vdd.t9 gnd 0.00357fF
C27 Vdd.n9 gnd 0.00715fF
C28 Vdd.n10 gnd 0.00115fF
C29 Vdd.n11 gnd 0.00288fF
C30 Vdd.n12 gnd 0.00137fF
C31 Vdd.n13 gnd 0.00070fF
C32 Vdd.n14 gnd 0.00273fF
C33 Vdd.n15 gnd 0.00796fF
C34 Vdd.n16 gnd 0.00815fF
C35 Vdd.n17 gnd 0.01280fF
C36 Vdd.t6 gnd 0.00357fF
C37 Vdd.t0 gnd 0.00357fF
C38 Vdd.n18 gnd 0.00715fF
C39 Vdd.n19 gnd 0.00115fF
C40 Vdd.n20 gnd 0.00288fF
C41 Vdd.n21 gnd 0.00137fF
C42 Vdd.n22 gnd 0.00070fF
C43 Vdd.n23 gnd 0.00273fF
C44 Vdd.n24 gnd 0.00796fF
C45 Vdd.n25 gnd 0.00815fF
C46 Vdd.n26 gnd 0.01280fF
C47 Vdd.t19 gnd 0.00357fF
C48 Vdd.t11 gnd 0.00357fF
C49 Vdd.n27 gnd 0.00715fF
C50 Vdd.n28 gnd 0.00115fF
C51 Vdd.n29 gnd 0.00288fF
C52 Vdd.n30 gnd 0.00137fF
C53 Vdd.n31 gnd 0.00070fF
C54 Vdd.n32 gnd 0.00273fF
C55 Vdd.n33 gnd 0.00796fF
C56 Vdd.n34 gnd 0.00815fF
C57 Vdd.n35 gnd 0.01280fF
C58 Vdd.t8 gnd 0.00357fF
C59 Vdd.t1 gnd 0.00357fF
C60 Vdd.n36 gnd 0.00715fF
C61 Vdd.n37 gnd 0.00115fF
C62 Vdd.n38 gnd 0.00288fF
C63 Vdd.n39 gnd 0.00137fF
C64 Vdd.n40 gnd 0.00070fF
C65 Vdd.n41 gnd 0.00273fF
C66 Vdd.n42 gnd 0.00796fF
C67 Vdd.n43 gnd 0.00815fF
C68 Vdd.n44 gnd 0.01280fF
C69 Vdd.t24 gnd 0.00357fF
C70 Vdd.t17 gnd 0.00357fF
C71 Vdd.n45 gnd 0.00715fF
C72 Vdd.n46 gnd 0.00115fF
C73 Vdd.n47 gnd 0.00288fF
C74 Vdd.n48 gnd 0.00137fF
C75 Vdd.n49 gnd 0.00070fF
C76 Vdd.n50 gnd 0.00273fF
C77 Vdd.n51 gnd 0.00796fF
C78 Vdd.n52 gnd 0.00815fF
C79 Vdd.n53 gnd 0.01280fF
C80 Vdd.t14 gnd 0.00357fF
C81 Vdd.t29 gnd 0.00357fF
C82 Vdd.n54 gnd 0.00715fF
C83 Vdd.n55 gnd 0.00115fF
C84 Vdd.n56 gnd 0.00288fF
C85 Vdd.n57 gnd 0.00137fF
C86 Vdd.n58 gnd 0.00070fF
C87 Vdd.n59 gnd 0.00273fF
C88 Vdd.n60 gnd 0.00796fF
C89 Vdd.n61 gnd 0.00815fF
C90 Vdd.n62 gnd 0.01280fF
C91 Vdd.t27 gnd 0.00357fF
C92 Vdd.t21 gnd 0.00357fF
C93 Vdd.n63 gnd 0.00715fF
C94 Vdd.n64 gnd 0.00115fF
C95 Vdd.n65 gnd 0.00288fF
C96 Vdd.n66 gnd 0.00137fF
C97 Vdd.n67 gnd 0.00070fF
C98 Vdd.n68 gnd 0.00273fF
C99 Vdd.n69 gnd 0.00796fF
C100 Vdd.n70 gnd 0.00815fF
C101 Vdd.n71 gnd 0.02022fF
C102 Vdd.n72 gnd 0.17506fF
C103 Vdd.n73 gnd 0.10708fF
C104 Vdd.n74 gnd 0.10708fF
C105 Vdd.n75 gnd 0.10708fF
C106 Vdd.n76 gnd 0.10708fF
C107 Vdd.n77 gnd 0.10708fF
C108 Vdd.t12 gnd 0.00357fF
C109 Vdd.t4 gnd 0.00357fF
C110 Vdd.n78 gnd 0.00715fF
C111 Vdd.n79 gnd 0.00115fF
C112 Vdd.n80 gnd 0.00288fF
C113 Vdd.n81 gnd 0.00137fF
C114 Vdd.n82 gnd 0.00070fF
C115 Vdd.n83 gnd 0.00273fF
C116 Vdd.n84 gnd 0.00796fF
C117 Vdd.n85 gnd 0.00815fF
C118 Vdd.n86 gnd 0.01280fF
C119 Vdd.t22 gnd 0.00357fF
C120 Vdd.t15 gnd 0.00357fF
C121 Vdd.n87 gnd 0.00715fF
C122 Vdd.n88 gnd 0.00115fF
C123 Vdd.n89 gnd 0.00288fF
C124 Vdd.n90 gnd 0.00137fF
C125 Vdd.n91 gnd 0.00070fF
C126 Vdd.n92 gnd 0.00273fF
C127 Vdd.n93 gnd 0.00796fF
C128 Vdd.n94 gnd 0.00815fF
C129 Vdd.n95 gnd 0.01280fF
C130 Vdd.t10 gnd 0.00357fF
C131 Vdd.t3 gnd 0.00357fF
C132 Vdd.n96 gnd 0.00715fF
C133 Vdd.n97 gnd 0.00115fF
C134 Vdd.n98 gnd 0.00288fF
C135 Vdd.n99 gnd 0.00137fF
C136 Vdd.n100 gnd 0.00070fF
C137 Vdd.n101 gnd 0.00273fF
C138 Vdd.n102 gnd 0.00796fF
C139 Vdd.n103 gnd 0.00815fF
C140 Vdd.n104 gnd 0.01280fF
C141 Vdd.t28 gnd 0.00357fF
C142 Vdd.t13 gnd 0.00357fF
C143 Vdd.n105 gnd 0.00715fF
C144 Vdd.n106 gnd 0.00115fF
C145 Vdd.n107 gnd 0.00288fF
C146 Vdd.n108 gnd 0.00137fF
C147 Vdd.n109 gnd 0.00070fF
C148 Vdd.n110 gnd 0.00273fF
C149 Vdd.n111 gnd 0.00796fF
C150 Vdd.n112 gnd 0.00815fF
C151 Vdd.n113 gnd 0.01280fF
C152 Vdd.t5 gnd 0.00357fF
C153 Vdd.t23 gnd 0.00357fF
C154 Vdd.n114 gnd 0.00715fF
C155 Vdd.n115 gnd 0.00115fF
C156 Vdd.n116 gnd 0.00288fF
C157 Vdd.n117 gnd 0.00137fF
C158 Vdd.n118 gnd 0.00070fF
C159 Vdd.n119 gnd 0.00273fF
C160 Vdd.n120 gnd 0.00796fF
C161 Vdd.n121 gnd 0.00815fF
C162 Vdd.n122 gnd 0.01280fF
C163 Vdd.t16 gnd 0.00357fF
C164 Vdd.t7 gnd 0.00357fF
C165 Vdd.n123 gnd 0.00715fF
C166 Vdd.n124 gnd 0.00115fF
C167 Vdd.n125 gnd 0.00288fF
C168 Vdd.n126 gnd 0.00137fF
C169 Vdd.n127 gnd 0.00070fF
C170 Vdd.n128 gnd 0.00273fF
C171 Vdd.n129 gnd 0.00796fF
C172 Vdd.n130 gnd 0.00815fF
C173 Vdd.n131 gnd 0.01280fF
C174 Vdd.t26 gnd 0.00357fF
C175 Vdd.t18 gnd 0.00357fF
C176 Vdd.n132 gnd 0.00715fF
C177 Vdd.n133 gnd 0.00115fF
C178 Vdd.n134 gnd 0.00288fF
C179 Vdd.n135 gnd 0.00137fF
C180 Vdd.n136 gnd 0.00070fF
C181 Vdd.n137 gnd 0.00273fF
C182 Vdd.n138 gnd 0.00796fF
C183 Vdd.n139 gnd 0.00815fF
C184 Vdd.n140 gnd 0.02022fF
C185 Vdd.n141 gnd 0.17506fF
C186 Vdd.n142 gnd 0.10708fF
C187 Vdd.n143 gnd 0.10708fF
C188 Vdd.n144 gnd 0.10708fF
C189 Vdd.n145 gnd 0.10708fF
C190 Vdd.n146 gnd 0.10708fF
C191 Vdd.n147 gnd 21.09530fF
C192 Vdd.t30 gnd 21.46900fF
C193 Vctrl.t2 gnd 0.00609fF
C194 Vctrl.t15 gnd 0.00609fF
C195 Vctrl.t5 gnd 0.00609fF
C196 Vctrl.t22 gnd 0.00609fF
C197 Vctrl.t10 gnd 0.00609fF
C198 Vctrl.t24 gnd 0.00609fF
C199 Vctrl.t4 gnd 0.00609fF
C200 Vctrl.t28 gnd 0.00609fF
C201 Vctrl.t17 gnd 0.00609fF
C202 Vctrl.t7 gnd 0.00609fF
C203 Vctrl.t20 gnd 0.00609fF
C204 Vctrl.t1 gnd 0.00609fF
C205 Vctrl.t25 gnd 0.00609fF
C206 Vctrl.t13 gnd 0.00609fF
C207 Vctrl.t3 gnd 0.00614fF
C208 Vctrl.n0 gnd 0.12555fF
C209 Vctrl.n1 gnd 0.06243fF
C210 Vctrl.n2 gnd 0.06243fF
C211 Vctrl.n3 gnd 0.06243fF
C212 Vctrl.n4 gnd 0.06243fF
C213 Vctrl.n5 gnd 0.06243fF
C214 Vctrl.n6 gnd 0.06243fF
C215 Vctrl.n7 gnd 0.06243fF
C216 Vctrl.n8 gnd 0.06243fF
C217 Vctrl.n9 gnd 0.06243fF
C218 Vctrl.n10 gnd 0.06243fF
C219 Vctrl.n11 gnd 0.06243fF
C220 Vctrl.n12 gnd 0.06243fF
C221 Vctrl.n13 gnd 0.09446fF
C222 Vctrl.t8 gnd 0.00609fF
C223 Vctrl.t0 gnd 0.00609fF
C224 Vctrl.t12 gnd 0.00609fF
C225 Vctrl.t29 gnd 0.00609fF
C226 Vctrl.t18 gnd 0.00609fF
C227 Vctrl.t30 gnd 0.00609fF
C228 Vctrl.t21 gnd 0.00609fF
C229 Vctrl.t9 gnd 0.00609fF
C230 Vctrl.t26 gnd 0.00609fF
C231 Vctrl.t14 gnd 0.00609fF
C232 Vctrl.t27 gnd 0.00609fF
C233 Vctrl.t16 gnd 0.00609fF
C234 Vctrl.t6 gnd 0.00609fF
C235 Vctrl.t23 gnd 0.00609fF
C236 Vctrl.t11 gnd 0.00613fF
C237 Vctrl.n14 gnd 0.11254fF
C238 Vctrl.n15 gnd 0.06243fF
C239 Vctrl.n16 gnd 0.06243fF
C240 Vctrl.n17 gnd 0.06243fF
C241 Vctrl.n18 gnd 0.06243fF
C242 Vctrl.n19 gnd 0.06243fF
C243 Vctrl.n20 gnd 0.06243fF
C244 Vctrl.n21 gnd 0.06243fF
C245 Vctrl.n22 gnd 0.06243fF
C246 Vctrl.n23 gnd 0.06243fF
C247 Vctrl.n24 gnd 0.06243fF
C248 Vctrl.n25 gnd 0.06243fF
C249 Vctrl.n26 gnd 0.06243fF
C250 Vctrl.n27 gnd 0.10250fF
C251 Vctrl.n28 gnd 7.54327fF
C252 Vctrl.t19 gnd 30.19080fF
C253 in.t3 gnd 0.00603fF
C254 in.t16 gnd 0.00597fF
C255 in.n0 gnd 0.12769fF
C256 in.t1 gnd 0.00597fF
C257 in.n1 gnd 0.06126fF
C258 in.t22 gnd 0.00597fF
C259 in.n2 gnd 0.06126fF
C260 in.t12 gnd 0.00597fF
C261 in.n3 gnd 0.06126fF
C262 in.t24 gnd 0.00597fF
C263 in.n4 gnd 0.06126fF
C264 in.t13 gnd 0.00597fF
C265 in.n5 gnd 0.06126fF
C266 in.t28 gnd 0.00597fF
C267 in.n6 gnd 0.06126fF
C268 in.t18 gnd 0.00597fF
C269 in.n7 gnd 0.06126fF
C270 in.t8 gnd 0.00597fF
C271 in.n8 gnd 0.06126fF
C272 in.t20 gnd 0.00597fF
C273 in.n9 gnd 0.06126fF
C274 in.t10 gnd 0.00597fF
C275 in.n10 gnd 0.06126fF
C276 in.t26 gnd 0.00597fF
C277 in.n11 gnd 0.06126fF
C278 in.t15 gnd 0.00597fF
C279 in.n12 gnd 0.06126fF
C280 in.t29 gnd 0.00597fF
C281 in.n13 gnd 0.09029fF
C282 in.t19 gnd 0.00601fF
C283 in.t9 gnd 0.00597fF
C284 in.n14 gnd 0.11043fF
C285 in.t25 gnd 0.00597fF
C286 in.n15 gnd 0.06126fF
C287 in.t14 gnd 0.00597fF
C288 in.n16 gnd 0.06126fF
C289 in.t5 gnd 0.00597fF
C290 in.n17 gnd 0.06126fF
C291 in.t7 gnd 0.00597fF
C292 in.n18 gnd 0.06126fF
C293 in.t0 gnd 0.00597fF
C294 in.n19 gnd 0.06126fF
C295 in.t21 gnd 0.00597fF
C296 in.n20 gnd 0.06126fF
C297 in.t11 gnd 0.00597fF
C298 in.n21 gnd 0.06126fF
C299 in.t2 gnd 0.00597fF
C300 in.n22 gnd 0.06126fF
C301 in.t4 gnd 0.00597fF
C302 in.n23 gnd 0.06126fF
C303 in.t27 gnd 0.00597fF
C304 in.n24 gnd 0.06126fF
C305 in.t17 gnd 0.00597fF
C306 in.n25 gnd 0.06126fF
C307 in.t6 gnd 0.00597fF
C308 in.n26 gnd 0.06126fF
C309 in.t23 gnd 0.00597fF
C310 in.n27 gnd 0.09701fF
C311 in.n28 gnd 1.23827fF
C312 out.t19 gnd 0.00385fF
C313 out.t13 gnd 0.00385fF
C314 out.n0 gnd 0.00771fF
C315 out.n1 gnd 0.00124fF
C316 out.n2 gnd 0.00311fF
C317 out.n3 gnd 0.00147fF
C318 out.n4 gnd 0.00076fF
C319 out.n5 gnd 0.00294fF
C320 out.n6 gnd 0.00859fF
C321 out.n7 gnd 0.00878fF
C322 out.n8 gnd 0.01380fF
C323 out.t6 gnd 0.00385fF
C324 out.t22 gnd 0.00385fF
C325 out.n9 gnd 0.00771fF
C326 out.n10 gnd 0.00124fF
C327 out.n11 gnd 0.00311fF
C328 out.n12 gnd 0.00147fF
C329 out.n13 gnd 0.00076fF
C330 out.n14 gnd 0.00294fF
C331 out.n15 gnd 0.00859fF
C332 out.n16 gnd 0.00878fF
C333 out.n17 gnd 0.01380fF
C334 out.t14 gnd 0.00385fF
C335 out.t28 gnd 0.00385fF
C336 out.n18 gnd 0.00771fF
C337 out.n19 gnd 0.00124fF
C338 out.n20 gnd 0.00311fF
C339 out.n21 gnd 0.00147fF
C340 out.n22 gnd 0.00076fF
C341 out.n23 gnd 0.00294fF
C342 out.n24 gnd 0.00859fF
C343 out.n25 gnd 0.00878fF
C344 out.n26 gnd 0.01380fF
C345 out.t24 gnd 0.00385fF
C346 out.t16 gnd 0.00385fF
C347 out.n27 gnd 0.00771fF
C348 out.n28 gnd 0.00124fF
C349 out.n29 gnd 0.00311fF
C350 out.n30 gnd 0.00147fF
C351 out.n31 gnd 0.00076fF
C352 out.n32 gnd 0.00294fF
C353 out.n33 gnd 0.00859fF
C354 out.n34 gnd 0.00878fF
C355 out.n35 gnd 0.01380fF
C356 out.t1 gnd 0.00385fF
C357 out.t26 gnd 0.00385fF
C358 out.n36 gnd 0.00771fF
C359 out.n37 gnd 0.00124fF
C360 out.n38 gnd 0.00311fF
C361 out.n39 gnd 0.00147fF
C362 out.n40 gnd 0.00076fF
C363 out.n41 gnd 0.00294fF
C364 out.n42 gnd 0.00859fF
C365 out.n43 gnd 0.00878fF
C366 out.n44 gnd 0.01380fF
C367 out.t18 gnd 0.00385fF
C368 out.t12 gnd 0.00385fF
C369 out.n45 gnd 0.00771fF
C370 out.n46 gnd 0.00124fF
C371 out.n47 gnd 0.00311fF
C372 out.n48 gnd 0.00147fF
C373 out.n49 gnd 0.00076fF
C374 out.n50 gnd 0.00294fF
C375 out.n51 gnd 0.00859fF
C376 out.n52 gnd 0.00878fF
C377 out.n53 gnd 0.01380fF
C378 out.t5 gnd 0.00385fF
C379 out.t21 gnd 0.00385fF
C380 out.n54 gnd 0.00771fF
C381 out.n55 gnd 0.00124fF
C382 out.n56 gnd 0.00311fF
C383 out.n57 gnd 0.00147fF
C384 out.n58 gnd 0.00076fF
C385 out.n59 gnd 0.00294fF
C386 out.n60 gnd 0.00858fF
C387 out.n61 gnd 0.00879fF
C388 out.n62 gnd 0.02180fF
C389 out.n63 gnd 0.18876fF
C390 out.n64 gnd 0.11547fF
C391 out.n65 gnd 0.11547fF
C392 out.n66 gnd 0.11547fF
C393 out.n67 gnd 0.11547fF
C394 out.n68 gnd 0.11547fF
C395 out.t0 gnd 0.00385fF
C396 out.t25 gnd 0.00385fF
C397 out.n69 gnd 0.00771fF
C398 out.n70 gnd 0.00124fF
C399 out.n71 gnd 0.00311fF
C400 out.n72 gnd 0.00147fF
C401 out.n73 gnd 0.00076fF
C402 out.n74 gnd 0.00294fF
C403 out.n75 gnd 0.00859fF
C404 out.n76 gnd 0.00878fF
C405 out.n77 gnd 0.01380fF
C406 out.t23 gnd 0.00385fF
C407 out.t8 gnd 0.00385fF
C408 out.n78 gnd 0.00771fF
C409 out.n79 gnd 0.00124fF
C410 out.n80 gnd 0.00311fF
C411 out.n81 gnd 0.00147fF
C412 out.n82 gnd 0.00076fF
C413 out.n83 gnd 0.00294fF
C414 out.n84 gnd 0.00859fF
C415 out.n85 gnd 0.00878fF
C416 out.n86 gnd 0.01380fF
C417 out.t2 gnd 0.00385fF
C418 out.t17 gnd 0.00385fF
C419 out.n87 gnd 0.00771fF
C420 out.n88 gnd 0.00124fF
C421 out.n89 gnd 0.00311fF
C422 out.n90 gnd 0.00147fF
C423 out.n91 gnd 0.00076fF
C424 out.n92 gnd 0.00294fF
C425 out.n93 gnd 0.00859fF
C426 out.n94 gnd 0.00878fF
C427 out.n95 gnd 0.01380fF
C428 out.t15 gnd 0.00385fF
C429 out.t9 gnd 0.00385fF
C430 out.n96 gnd 0.00771fF
C431 out.n97 gnd 0.00124fF
C432 out.n98 gnd 0.00311fF
C433 out.n99 gnd 0.00147fF
C434 out.n100 gnd 0.00076fF
C435 out.n101 gnd 0.00294fF
C436 out.n102 gnd 0.00859fF
C437 out.n103 gnd 0.00878fF
C438 out.n104 gnd 0.01380fF
C439 out.t7 gnd 0.00385fF
C440 out.t29 gnd 0.00385fF
C441 out.n105 gnd 0.00771fF
C442 out.n106 gnd 0.00124fF
C443 out.n107 gnd 0.00311fF
C444 out.n108 gnd 0.00147fF
C445 out.n109 gnd 0.00076fF
C446 out.n110 gnd 0.00294fF
C447 out.n111 gnd 0.00859fF
C448 out.n112 gnd 0.00878fF
C449 out.n113 gnd 0.01380fF
C450 out.t27 gnd 0.00385fF
C451 out.t20 gnd 0.00385fF
C452 out.n114 gnd 0.00771fF
C453 out.n115 gnd 0.00124fF
C454 out.n116 gnd 0.00311fF
C455 out.n117 gnd 0.00147fF
C456 out.n118 gnd 0.00076fF
C457 out.n119 gnd 0.00294fF
C458 out.n120 gnd 0.00859fF
C459 out.n121 gnd 0.00878fF
C460 out.n122 gnd 0.01380fF
C461 out.t11 gnd 0.00385fF
C462 out.t4 gnd 0.00385fF
C463 out.n123 gnd 0.00771fF
C464 out.n124 gnd 0.00124fF
C465 out.n125 gnd 0.00311fF
C466 out.n126 gnd 0.00147fF
C467 out.n127 gnd 0.00076fF
C468 out.n128 gnd 0.00294fF
C469 out.n129 gnd 0.00859fF
C470 out.n130 gnd 0.00878fF
C471 out.n131 gnd 0.02180fF
C472 out.n132 gnd 0.18876fF
C473 out.n133 gnd 0.11547fF
C474 out.n134 gnd 0.11547fF
C475 out.n135 gnd 0.11547fF
C476 out.n136 gnd 0.11547fF
C477 out.n137 gnd 0.11547fF
C478 out.t10 gnd 0.00385fF
C479 out.t3 gnd 0.00385fF
C480 out.n138 gnd 0.00771fF
C481 out.n139 gnd 0.00124fF
C482 out.n140 gnd 0.00311fF
C483 out.n141 gnd 0.00147fF
C484 out.n142 gnd 0.00076fF
C485 out.n143 gnd 0.00294fF
C486 out.n144 gnd 0.00859fF
C487 out.n145 gnd 0.00878fF
C488 out.n146 gnd 0.01380fF
C489 out.n147 gnd 19.61440fF
C490 gate.t25 gnd 0.00616fF
C491 gate.t9 gnd 0.00611fF
C492 gate.n0 gnd 0.12601fF
C493 gate.t0 gnd 0.00611fF
C494 gate.n1 gnd 0.06266fF
C495 gate.t20 gnd 0.00611fF
C496 gate.n2 gnd 0.06266fF
C497 gate.t12 gnd 0.00611fF
C498 gate.n3 gnd 0.06266fF
C499 gate.t21 gnd 0.00611fF
C500 gate.n4 gnd 0.06266fF
C501 gate.t4 gnd 0.00611fF
C502 gate.n5 gnd 0.06266fF
C503 gate.t26 gnd 0.00611fF
C504 gate.n6 gnd 0.06266fF
C505 gate.t16 gnd 0.00611fF
C506 gate.n7 gnd 0.06266fF
C507 gate.t7 gnd 0.00611fF
C508 gate.n8 gnd 0.06266fF
C509 gate.t1 gnd 0.00611fF
C510 gate.n9 gnd 0.06266fF
C511 gate.t13 gnd 0.00611fF
C512 gate.n10 gnd 0.06266fF
C513 gate.t3 gnd 0.00611fF
C514 gate.n11 gnd 0.06266fF
C515 gate.t17 gnd 0.00611fF
C516 gate.n12 gnd 0.06266fF
C517 gate.t8 gnd 0.00611fF
C518 gate.n13 gnd 0.09430fF
C519 gate.t18 gnd 0.00615fF
C520 gate.t2 gnd 0.00611fF
C521 gate.n14 gnd 0.11296fF
C522 gate.t22 gnd 0.00611fF
C523 gate.n15 gnd 0.06266fF
C524 gate.t14 gnd 0.00611fF
C525 gate.n16 gnd 0.06266fF
C526 gate.t27 gnd 0.00611fF
C527 gate.n17 gnd 0.06266fF
C528 gate.t6 gnd 0.00611fF
C529 gate.n18 gnd 0.06266fF
C530 gate.t29 gnd 0.00611fF
C531 gate.n19 gnd 0.06266fF
C532 gate.t19 gnd 0.00611fF
C533 gate.n20 gnd 0.06266fF
C534 gate.t10 gnd 0.00611fF
C535 gate.n21 gnd 0.06266fF
C536 gate.t23 gnd 0.00611fF
C537 gate.n22 gnd 0.06266fF
C538 gate.t15 gnd 0.00611fF
C539 gate.n23 gnd 0.06266fF
C540 gate.t5 gnd 0.00611fF
C541 gate.n24 gnd 0.06266fF
C542 gate.t28 gnd 0.00611fF
C543 gate.n25 gnd 0.06266fF
C544 gate.t11 gnd 0.00611fF
C545 gate.n26 gnd 0.06266fF
C546 gate.t24 gnd 0.00611fF
C547 gate.n27 gnd 0.10169fF
C548 gate.n28 gnd 2.19828fF


**** end user architecture code
**.ends
.end
